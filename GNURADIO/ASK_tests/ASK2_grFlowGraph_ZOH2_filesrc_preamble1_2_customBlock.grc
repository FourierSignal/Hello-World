options:
  parameters:
    generate_options: qt_gui
    id: ASK_grFlowgraph
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: excess_bw
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: fc
  id: variable
  parameters:
    value: '8000'
  states: {}
- name: interpolation_factor
  id: variable
  parameters:
    value: '256'
  states: {}
- name: ntaps
  id: variable
  parameters:
    comment: |-
      for short bursts of data like 8 symbols 
      ntaps = 16 is ok.  which introduce very small group delay and it does not distort the signal
    value: int(0.5*interpolation_factor*1)
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: numpy.array ( firdes.root_raised_cosine(10,samp_rate,symbol_rate, excess_bw,16 ))
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: symbol_rate * interpolation_factor
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: 2*50
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: fc
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: fc
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /media/linux1/600GB_EXT4/GNU_radio/GNURadio_src_dev_test_dir/03_flowgraphs/BPSK_tests/hello_out.txt
    type: byte
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: /media/linux1/600GB_EXT4/GNU_radio/GNURadio_src_dev_test_dir/03_flowgraphs/BPSK_tests/hello.txt
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_float_to_uchar_0
  id: blocks_float_to_uchar
  parameters:
    bias: '0'
    scale: '1'
    vlen: '1'
  states: {}
- name: blocks_keep_m_in_n_0
  id: blocks_keep_m_in_n
  parameters:
    m: ((8*interpolation_factor)*1)+(ntaps*2)
    n: (8*interpolation_factor)*2
    offset: '0'
    type: float
  states: {state: disabled}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_stream_mux_0_0
  id: blocks_stream_mux
  parameters:
    lengths: (1 ,1)
    type: byte
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    filter: '"packet_len"'
    name: demod_debug
    type: float
  states: {}
- name: blocks_tag_debug_0_0
  id: blocks_tag_debug
  parameters:
    filter: '"packet_len"'
    name: symbolgen_debug
    type: float
  states: {}
- name: blocks_tag_debug_0_1
  id: blocks_tag_debug
  parameters:
    filter: '"packet_len"'
    name: fir_debug
    type: float
  states: {}
- name: blocks_tag_gate_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'True'
    type: float
  states: {state: disabled}
- name: blocks_tagged_stream_align_0
  id: blocks_tagged_stream_align
  parameters:
    lengthtagname: packet_len
    type: float
  states: {state: disabled}
- name: blocks_tagged_stream_align_0_0
  id: blocks_tagged_stream_align
  parameters:
    lengthtagname: packet_len
    type: float
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '1'
    type: float
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: '60'
    init: '0'
    low: '10'
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    maximum: '2'
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    maximum: '2'
    maxoutbuf: '200'
    minoutbuf: '200'
    samples_per_second: symbol_rate
    type: float
  states: {}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_vector_source_x_0_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'False'
    type: byte
    vector: '[0x00] '
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: float
    symbol_table: '[0,1]'
  states: {}
- name: digital_correlate_access_code_tag_xx_1
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: '10101010'
    tagname: packet_start
    threshold: '0'
    type: float
  states: {state: disabled}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport numpy as np\nimport pmt\nfrom gnuradio import gr\n\nclass custom_tag_adder(gr.sync_block):\n    def __init__(self):\n        gr.sync_block.__init__(self, name=\"Custom Tag Adder\", in_sig=[np.float32], out_sig=[np.float32])\n        self.first_sample = True\n\n    def work(self, input_items, output_items):\n        if self.first_sample:\n            # Add packet_len tag at offset 0\n            tag = gr.tag_t()\n            tag.offset = self.nitems_written(0)\n            tag.key = pmt.intern(\"packet_len\")\n            tag.value = pmt.from_long(9)  # 8 bits for 1 byte\n            self.add_item_tag(0, tag)\n            self.first_sample = False\n        output_items[0][:] = input_items[0][:]\n        return len(output_items[0])\n\n\n"
  states: {}
- name: epy_block_0_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """


      import numpy as np
      from gnuradio import gr

      class float_display_block(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(self,
                  name="Float Display Block",
                  in_sig=[np.float32],
                  out_sig=None)
              self.item_counter = 0  # Initialize item counter

          def work(self, input_items, output_items):
              for i, val in enumerate(input_items[0]):  
                  print(f"1.Float[{i}]: {val:.4f}")
                  self.item_counter += 1 
              print(f"Total items printed: {self.item_counter}")
              return len(input_items[0])  # Consume all input items
  states: {}
- name: epy_block_0_0_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """


      import numpy as np
      from gnuradio import gr

      class float_display_block(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(self,
                  name="Byte Display Block",
                  in_sig=[np.float32],
                  out_sig=None)
              self.item_counter = 0  # Initialize item counter

          def work(self, input_items, output_items):
              for i, val in enumerate(input_items[0]):  
                  #print(f"Float[{i}]: {val:.4f}")
                  self.item_counter += 1 
              print(f"Total items printed: {self.item_counter}")
              return len(input_items[0])  # Consume all input items
  states: {state: disabled}
- name: epy_block_0_0_0_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """


      import numpy as np
      from gnuradio import gr

      class float_display_block(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(self,
                  name="Byte Display Block",
                  in_sig=[np.float32],
                  out_sig=None)
              self.item_counter = 0  # Initialize item counter

          def work(self, input_items, output_items):
              for i, val in enumerate(input_items[0]):  
                  print(f"Float[{i}]: {val:.4f}")
                  self.item_counter += 1 
              print(f"Total items printed: {self.item_counter}")
              return len(input_items[0])  # Consume all input items
  states: {state: disabled}
- name: epy_block_0_0_0_0_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """


      import numpy as np
      from gnuradio import gr

      class float_display_block(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(self,
                  name="Float Display Block",
                  in_sig=[np.float32],
                  out_sig=None)
              self.item_counter = 0  # Initialize item counter

          def work(self, input_items, output_items):
              for i, val in enumerate(input_items[0]):  
                  print(f"Float[{i}]: {val:.4f}")
                  self.item_counter += 1 
              print(f"Total items printed: {self.item_counter}")
              return len(input_items[0])  # Consume all input items
  states: {}
- name: epy_block_0_0_0_0_0_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """


      import numpy as np
      from gnuradio import gr

      class float_display_block(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(self,
                  name="Float Display Block",
                  in_sig=[np.float32],
                  out_sig=None)
              self.item_counter = 0  # Initialize item counter

          def work(self, input_items, output_items):
              for i, val in enumerate(input_items[0]):  
                  print(f"Float[{i}]: {val:.4f}")
                  self.item_counter += 1 
              print(f"Total items printed: {self.item_counter}")
              return len(input_items[0])  # Consume all input items
  states: {state: disabled}
- name: epy_block_0_0_0_1
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """


      import numpy as np
      from gnuradio import gr

      class byte_display_block(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(self,
                  name="Byte Display Block",
                  in_sig=[np.byte],
                  out_sig=None)
              self.item_counter = 0  # Initialize item counter

          def work(self, input_items, output_items):
              for i, val in enumerate(input_items[0]):
                  print(f"Byte[{i}]: {val:02X}")  # Display as two-digit hexadecimal
                  self.item_counter += 1
              print(f"Total bytes printed: {self.item_counter}")
              return len(input_items[0])  # Consume all input items
  states: {state: disabled}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: samp_rate // symbol_rate
    taps: numpy.ones(ntaps)
    type: fff
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: interpolation_factor
    taps: numpy.ones(interpolation_factor)
    type: fff
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: 'samp_rate '
    fc: '0'
    fftsize: 1024*2
    name: '"Freq Response of BaseBandSignal"'
    type: float
    update_time: '2'
    wintype: window.WIN_KAISER
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: 1024*2
    name: '"Freq Response of PassBandSignal"'
    type: float
    update_time: '500'
    wintype: window.WIN_KAISER
  states: {}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: 1024*2
    name: '"Freq Response of Demodulated baseBand Signal"'
    type: float
    update_time: '500'
  states: {}
- name: qtgui_freq_sink_x_0_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: (samp_rate/interpolation_factor)/2
    fc: '0'
    fftsize: 1024*2
    name: '"Freq Response of DecimatedFIR o/p"'
    type: float
    update_time: '0.0001'
    ymax: '1'
  states: {state: disabled}
- name: qtgui_time_sink_x_4_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    name: '"BaseBandSignal"'
    size: 2*256
    srate: samp_rate
    type: float
    update_time: '1'
  states: {}
- name: qtgui_time_sink_x_4_1_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    name: '"PassBandSignal"'
    size: 100*256
    srate: samp_rate
    type: float
    update_time: '1'
  states: {}
- name: qtgui_time_sink_x_4_1_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    comment: |-
      observe aliased frequency components at 10Khz
      cos(2π8kt)⋅cos(2π8kt)=  1/2*x(n) + 1/2*x(n)*cos(2π⋅16kt)

      Aliased frequency=16kHz−25.6kHz=−9.6kHz
    grid: 'True'
    name: '"demodulated Baseband Signal"'
    size: 100*256
    srate: samp_rate
    type: float
    update_time: '1'
  states: {}
- name: qtgui_time_sink_x_4_1_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    entags: 'False'
    grid: 'True'
    name: '"symbols"'
    size: '100'
    srate: 'symbol_rate '
    type: float
    update_time: '1'
  states: {}
- name: qtgui_time_sink_x_4_1_2
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    name: '"Recovered BaseBandSignal"'
    size: '100'
    srate: samp_rate//interpolation_factor
    type: float
    update_time: '1'
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: BaseBand_Signal
  states: {}
- name: virtual_sink_1_0
  id: virtual_sink
  parameters:
    stream_id: Passband_ASKsignal
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: BaseBand_Signal
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: BaseBand_Signal
  states: {}
- name: virtual_source_1_0_0
  id: virtual_source
  parameters:
    stream_id: Passband_ASKsignal
  states: {}
- name: virtual_source_1_0_0_0
  id: virtual_source
  parameters:
    stream_id: Passband_ASKsignal
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0_0, '1']
- [blocks_file_source_0_0, '0', blocks_stream_mux_0_0, '0']
- [blocks_float_to_char_0, '0', blocks_unpacked_to_packed_xx_0, '0']
- [blocks_float_to_uchar_0, '0', blocks_unpacked_to_packed_xx_0, '0']
- [blocks_keep_m_in_n_0, '0', blocks_throttle2_0, '0']
- [blocks_multiply_xx_0, '0', virtual_sink_1_0, '0']
- [blocks_multiply_xx_0_0, '0', blocks_tag_debug_0, '0']
- [blocks_multiply_xx_0_0, '0', epy_block_0_0_0_0, '0']
- [blocks_multiply_xx_0_0, '0', fir_filter_xxx_0, '0']
- [blocks_multiply_xx_0_0, '0', qtgui_freq_sink_x_0_0_0, '0']
- [blocks_multiply_xx_0_0, '0', qtgui_time_sink_x_4_1_0_0, '0']
- [blocks_packed_to_unpacked_xx_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [blocks_stream_mux_0_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [blocks_stream_mux_0_0, '0', epy_block_0_0_0_1, '0']
- [blocks_tagged_stream_align_0_0, '0', blocks_throttle2_0_0, '0']
- [blocks_tagged_stream_mux_0, '0', blocks_tag_debug_0_1, '0']
- [blocks_tagged_stream_mux_0, '0', blocks_threshold_ff_0, '0']
- [blocks_threshold_ff_0, '0', blocks_float_to_char_0, '0']
- [blocks_threshold_ff_0, '0', blocks_float_to_uchar_0, '0']
- [blocks_threshold_ff_0, '0', digital_correlate_access_code_tag_xx_1, '0']
- [blocks_threshold_ff_0, '0', epy_block_0_0_0_0_0_0, '0']
- [blocks_threshold_ff_0, '0', qtgui_time_sink_x_4_1_2, '0']
- [blocks_throttle2_0, '0', virtual_sink_1, '0']
- [blocks_throttle2_0_0, '0', blocks_tag_debug_0_0, '0']
- [blocks_throttle2_0_0, '0', epy_block_0_0_0, '0']
- [blocks_throttle2_0_0, '0', interp_fir_filter_xxx_0, '0']
- [blocks_throttle2_0_0, '0', qtgui_time_sink_x_4_1_1, '0']
- [blocks_unpacked_to_packed_xx_0, '0', blocks_file_sink_0, '0']
- [blocks_vector_source_x_0_0_0, '0', blocks_stream_mux_0_0, '1']
- [digital_chunks_to_symbols_xx_0, '0', epy_block_0, '0']
- [digital_correlate_access_code_tag_xx_1, '0', epy_block_0_0_0_0_0, '0']
- [epy_block_0, '0', blocks_tagged_stream_align_0_0, '0']
- [fir_filter_xxx_0, '0', blocks_tagged_stream_mux_0, '0']
- [interp_fir_filter_xxx_0, '0', blocks_keep_m_in_n_0, '0']
- [interp_fir_filter_xxx_0, '0', blocks_throttle2_0, '0']
- [virtual_source_1, '0', qtgui_freq_sink_x_0, '0']
- [virtual_source_1, '0', qtgui_time_sink_x_4_1, '0']
- [virtual_source_1_0, '0', blocks_multiply_xx_0, '0']
- [virtual_source_1_0_0, '0', qtgui_freq_sink_x_0_0, '0']
- [virtual_source_1_0_0, '0', qtgui_time_sink_x_4_1_0, '0']
- [virtual_source_1_0_0_0, '0', blocks_multiply_xx_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
