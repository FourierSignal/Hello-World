options:
  parameters:
    generate_options: qt_gui
    id: ASK_grFlowgraph
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: excess_bw
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: fc
  id: variable
  parameters:
    value: '8000'
  states: {}
- name: interpolation_factor
  id: variable
  parameters:
    value: '256'
  states: {}
- name: ntaps
  id: variable
  parameters:
    comment: |-
      for short bursts of data like 8 symbols 
      ntaps = 16 is ok.  which introduce very small group delay and it does not distort the signal
    value: (0.5*interpolation_factor*2)
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: numpy.array ( firdes.root_raised_cosine(10,samp_rate,symbol_rate, excess_bw,16 ))
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: symbol_rate * interpolation_factor
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: 2*50
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: fc
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: fc
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /media/linux1/600GB_EXT4/GNU_radio/GNURadio_src_dev_test_dir/03_flowgraphs/BPSK_tests/hello_out.txt
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: /media/linux1/600GB_EXT4/GNU_radio/GNURadio_src_dev_test_dir/03_flowgraphs/BPSK_tests/hello1.txt
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_float_to_uchar_0
  id: blocks_float_to_uchar
  parameters:
    bias: '0'
    scale: '1'
    vlen: '1'
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_stream_mux_0
  id: blocks_stream_mux
  parameters:
    lengths: (1, 200)
    type: byte
  states: {}
- name: blocks_stream_mux_0_0
  id: blocks_stream_mux
  parameters:
    lengths: (201,2)
    type: byte
  states: {}
- name: blocks_tag_debug_0_0_0
  id: blocks_tag_debug
  parameters:
    name: access_code_debug2
    type: byte
  states: {state: disabled}
- name: blocks_tag_debug_0_0_0_0
  id: blocks_tag_debug
  parameters:
    name: access_code_debug1
    type: byte
  states: {state: disabled}
- name: blocks_tag_debug_0_0_0_1
  id: blocks_tag_debug
  parameters:
    name: access_code_debug3
    type: byte
  states: {state: disabled}
- name: blocks_tagged_stream_align_0_0
  id: blocks_tagged_stream_align
  parameters:
    lengthtagname: packet_start
    type: byte
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: '120'
    init: '0'
    low: '10'
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    maximum: '2'
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    maximum: '2'
    maxoutbuf: '200'
    minoutbuf: '200'
    samples_per_second: symbol_rate
    type: float
  states: {}
- name: blocks_unpacked_to_packed_xx_0_1
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_vector_source_x_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'False'
    type: byte
    vector: '[0xaa] '
  states: {}
- name: blocks_vector_source_x_0_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'False'
    type: byte
    vector: '[0x0F,0x00] '
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: float
    symbol_table: '[0,1]'
  states: {}
- name: digital_correlate_access_code_tag_xx_1
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: '10101010'
    tagname: packet_start
    threshold: '0'
    type: byte
  states: {}
- name: digital_correlate_access_code_tag_xx_1_0
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: '10101010'
    tagname: packet_start
    threshold: '0'
    type: byte
  states: {state: disabled}
- name: digital_correlate_access_code_tag_xx_1_1
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: '00001111'
    tagname: packet_end
    threshold: '0'
    type: byte
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt
      import ast

      class ExtractPayLoad(gr.basic_block):
          """
          Forwards input data to output and simultaneously inspects and prints any tags.
          Input and output are streams of bit objects (numpy arrays of 0s and 1s).
          """

          def __init__(self):
              gr.basic_block.__init__(
                  self,
                  name='ExtractPayLoad',
                  in_sig=[np.int8],  # Input is a stream of bits (0 or 1)
                  out_sig=[np.int8]  # Output is a stream of bits (0 or 1)
              )
              self.payload_buffer = []
              self.in_payload = False

          def general_work(self, input_items, output_items):
              in_bits = input_items[0]
              out_bits = output_items[0]
              nread = self.nitems_read(0)
              tags = self.get_tags_in_window(0, 0, len(in_bits))
              tag_offsets = {tag.offset - nread: tag for tag in tags}

              # Directly forward the input to the output
              #out_bits[:] = in_bits
              print("----->in_bits=",in_bits)
              # Inspect and print tags present in the current input buffer
              for offset, tag in tag_offsets.items():
                  key = pmt.to_python(tag.key)
                  value = pmt.to_python(tag.value)
                  print(f"Tag Debug: Offset: {tag.offset}, Relative Offset: {offset}, Key: {key}, Value: {value}")

              consumed = 0
              produced = 0
              i = 0


              # If packet_end is reached and entire buffer is not sent out in previous call, Flush the data is Remaining in Buffer.
              # Output remaining payload if it exists and we're no longer in payload collection
              if not self.in_payload and self.payload_buffer:
                  output_len = min(len(self.payload_buffer), len(out_bits))
                  print("flushing:len(out_bits)=",len(out_bits), len(self.payload_buffer))
                  if output_len > 0:
                      out_bits[:output_len] = self.payload_buffer[:output_len]
                      self.payload_buffer = self.payload_buffer[output_len:]  # remove outputted
                      self.consume(0, 0)  # No new input consumed in this call
                      return output_len

              while i < len(in_bits):
                  if i in tag_offsets:
                      tag = tag_offsets[i]
                      key = pmt.to_python(tag.key)
                      print(key)

                      if key == 'packet_start':
                          print("Detected packet_start.")
                          self.in_payload = True
                          self.payload_buffer.clear()  

                      elif key == 'packet_end':
                          if self.in_payload:
                              print("Detected packet_end.")
                              #exit(0)
                              self.in_payload = False
                              
                              print("len(out_bits)=",len(out_bits), len(self.payload_buffer))
                              output_len = min(len(self.payload_buffer), len(out_bits)) # Output as much as fits
                              if output_len > 0:
                                  produced = output_len
                                  consumed = i+1
                                  print("--->produced=",produced,[int(x) for x in self.payload_buffer],"consumed=",consumed)
                                  out_bits[:output_len] = self.payload_buffer[:output_len]
                                  self.payload_buffer = self.payload_buffer[output_len:]
                                  self.consume(0, consumed) 
                                  return produced
                              
                  #print(i,in_bits[i]) 
                  if self.in_payload == True:
                      self.payload_buffer.append(in_bits[i])
                  i += 1
                  consumed = i
              
              print("produced=",produced,[int(x) for x in self.payload_buffer],"consumed=",consumed)
              self.consume(0,consumed)
              # The number of output items produced is the same as the number of input items consumed
              return produced
  states: {}
- name: epy_block_0_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """


      import numpy as np
      from gnuradio import gr

      class float_display_block(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(self,
                  name="Float Display Block",
                  in_sig=[np.float32],
                  out_sig=None)
              self.item_counter = 0  # Initialize item counter

          def work(self, input_items, output_items):
              for i, val in enumerate(input_items[0]):  
                  print(f"1.Float[{i}]: {val:.4f}")
                  self.item_counter += 1 
              print(f"Total items printed: {self.item_counter}")
              return len(input_items[0])  # Consume all input items
  states: {}
- name: epy_block_0_0_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """


      import numpy as np
      from gnuradio import gr

      class float_display_block(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(self,
                  name="Byte Display Block",
                  in_sig=[np.float32],
                  out_sig=None)
              self.item_counter = 0  # Initialize item counter

          def work(self, input_items, output_items):
              for i, val in enumerate(input_items[0]):  
                  #print(f"Float[{i}]: {val:.4f}")
                  self.item_counter += 1 
              print(f"Total items printed: {self.item_counter}")
              return len(input_items[0])  # Consume all input items
  states: {state: disabled}
- name: epy_block_0_0_0_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """


      import numpy as np
      from gnuradio import gr

      class float_display_block(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(self,
                  name="Byte Display Block",
                  in_sig=[np.uint8],
                  out_sig=None)
              self.item_counter = 0  # Initialize item counter

          def work(self, input_items, output_items):
              for i, val in enumerate(input_items[0]):  
                  print(f"Byte[{i}]: {val:02x}")
                  self.item_counter += 1 
              print(f"Total items printed: {self.item_counter}")
              return len(input_items[0])  # Consume all input items
  states: {state: disabled}
- name: epy_block_0_0_0_0_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """


      import numpy as np
      from gnuradio import gr

      class float_display_block(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(self,
                  name="Byte Display Block",
                  in_sig=[np.uint8],
                  out_sig=None)
              self.item_counter = 0  # Initialize item counter

          def work(self, input_items, output_items):
              for i, val in enumerate(input_items[0]):  
                  print(f"Byte[{i}]: {val:02x}")
                  self.item_counter += 1 
              print(f"Total items printed: {self.item_counter}")
              return len(input_items[0])  # Consume all input items
  states: {state: disabled}
- name: epy_block_0_0_0_0_0_0_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """


      import numpy as np
      from gnuradio import gr

      class float_display_block(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(self,
                  name="Byte Display Block",
                  in_sig=[np.uint8],
                  out_sig=None)
              self.item_counter = 0  # Initialize item counter

          def work(self, input_items, output_items):
              for i, val in enumerate(input_items[0]):  
                  print(f"Byte[{i}]: {val:02x}")
                  self.item_counter += 1 
              print(f"Total items printed: {self.item_counter}")
              return len(input_items[0])  # Consume all input items
  states: {state: disabled}
- name: epy_block_0_0_0_0_0_0_1_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """


      import numpy as np
      from gnuradio import gr

      class float_display_block(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(self,
                  name="Byte Display Block",
                  in_sig=[np.uint8],
                  out_sig=None)
              self.item_counter = 0  # Initialize item counter

          def work(self, input_items, output_items):
              for i, val in enumerate(input_items[0]):  
                  print(f"Byte[{i}]: {val:02x}")
                  self.item_counter += 1 
              print(f"Total items printed: {self.item_counter}")
              return len(input_items[0])  # Consume all input items
  states: {}
- name: epy_block_0_0_0_0_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """


      import numpy as np
      from gnuradio import gr

      class float_display_block(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(self,
                  name="Byte Display Block",
                  in_sig=[np.float32],
                  out_sig=None)
              self.item_counter = 0  # Initialize item counter

          def work(self, input_items, output_items):
              for i, val in enumerate(input_items[0]):  
                  print(f"Float[{i}]: {val:.4f}")
                  self.item_counter += 1 
              print(f"Total items printed: {self.item_counter}")
              return len(input_items[0])  # Consume all input items
  states: {state: disabled}
- name: epy_block_0_0_0_1
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """


      import numpy as np
      from gnuradio import gr

      class byte_display_block(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(self,
                  name="Byte Display Block",
                  in_sig=[np.byte],
                  out_sig=None)
              self.item_counter = 0  # Initialize item counter

          def work(self, input_items, output_items):
              for i, val in enumerate(input_items[0]):
                  print(f"Byte[{i}]: {val:02X}")  # Display as two-digit hexadecimal
                  self.item_counter += 1
              print(f"Total bytes printed: {self.item_counter}")
              return len(input_items[0])  # Consume all input items
  states: {state: disabled}
- name: epy_block_0_0_0_1_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """


      import numpy as np
      from gnuradio import gr

      class byte_display_block(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(self,
                  name="Byte Display Block",
                  in_sig=[np.byte],
                  out_sig=None)
              self.item_counter = 0  # Initialize item counter

          def work(self, input_items, output_items):
              for i, val in enumerate(input_items[0]):
                  print(f"Byte[{i}]: {val:02X}")  # Display as two-digit hexadecimal
                  self.item_counter += 1
              print(f"Total bytes printed: {self.item_counter}")
              return len(input_items[0])  # Consume all input items
  states: {state: disabled}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\nimport numpy as np\nfrom gnuradio import gr\nimport pmt\nimport ast\n\nclass extract_payload_block(gr.sync_block):\n    def __init__(self, postamble_pattern=None):\n        gr.basic_block.__init__(\n            self,\n            name=\"extract_payload_block\",\n            in_sig=[np.uint8],   # unpacked bits: 0 or 1\n            out_sig=[np.uint8]   # output same type\n        )\n        self.in_payload = False\n        self.buffer = []\n\n\n        print(f\"Type of postamble_pattern received: {type(postamble_pattern)}\")\n        print(f\"Value of postamble_pattern received: {postamble_pattern}\")\n\n        if isinstance(postamble_pattern, str):\n            try:\n                # Safely evaluate the string as a Python literal\n                self.postamble_pattern = ast.literal_eval(postamble_pattern)\n            except (SyntaxError, ValueError) as e:\n                raise ValueError(f\"Invalid format for postamble_pattern string: {e}\")\n        elif isinstance(postamble_pattern, (int, list, np.ndarray)):\n            # If it's already the correct type, use it directly\n            self.postamble_pattern = postamble_pattern\n        else:\n            raise TypeError(\"postamble_pattern must be a string representing a list, an integer, a list, or a NumPy array\")\n\n        print(f\"Type of self.postamble_pattern after processing: {type(self.postamble_pattern)}\")\n        print(f\"Value of self.postamble_pattern after processing: {self.postamble_pattern}\")\n\n\n\n\n        # Ensure postamble_pattern is a numpy array or list\n        self.postamble_pattern = postamble_pattern\n\n\n\n\n    def general_work(self, input_items, output_items):\n        in0 = input_items[0]\n        out = output_items[0]\n        nread = self.nitems_read(0)\n\n        tags = self.get_tags_in_window(0, 0, len(in0))\n        tag_offsets = {tag.offset - nread: tag for tag in tags}\n\n        i = 0\n        packet_start_idx = None\n        packet_end_idx = None\n\n        # Step 1: Detect start and end tags (packet_start and packet_end)\n        while i < len(in0):\n            if i in tag_offsets and tag_offsets[i].key == pmt.intern(\"packet_start\"):\n                self.in_payload = True\n                self.buffer.clear()\n                packet_start_idx = i\n\n            if i in tag_offsets and tag_offsets[i].key == pmt.intern(\"packet_end\"):\n                packet_end_idx = i\n                if self.in_payload:\n                    self.in_payload = False\n                    break  # Stop once packet_end is found\n\n            if self.in_payload:\n                self.buffer.append(in0[i])\n\n            i += 1\n\n        print(\"packet_end_idx=\",packet_end_idx)\n\n        if not isinstance(self.postamble_pattern, (int, list, np.ndarray)):\n            print(f\"Error: postamble_pattern has incorrect type: {type(self.postamble_pattern)}\")\n            return -1\n\n        # Step 2: If packet_end found, remove postamble\n        if packet_end_idx is not None:\n            # Check and remove postamble before packet_end\n            payload_end_idx = self._remove_postamble(packet_end_idx)\n            self.buffer = self.buffer[:payload_end_idx]\n\n        # Step 3: Output the extracted payload (without postamble)\n        num_to_output = min(len(out), len(self.buffer))\n        out[:num_to_output] = self.buffer[:num_to_output]\n        self.buffer = self.buffer[num_to_output:]\n\n        self.consume(0, i)\n        return num_to_output\n\n    def _remove_postamble(self, packet_end_idx):\n        \"\"\"Detect and remove postamble before the packet_end tag\"\"\"\n\n                # --- Normalize postamble_pattern to a list of ints ---\n\n        if isinstance(postamble_pattern, int):\n\n            postamble_pattern = [postamble_pattern]\n\n        elif isinstance(postamble_pattern, np.ndarray):\n\n            postamble_pattern = postamble_pattern.tolist()\n\n        elif not isinstance(postamble_pattern, list):\n\n            raise TypeError(\"postamble_pattern must be int, list, or numpy array\")\n\n        self.postamble_pattern = np.array(postamble_pattern, dtype=np.uint8) \n\n        print(\"self.postamble_pattern\",self.postamble_pattern,type(self.postamble_pattern))\n\n\n        print( type(self.postamble_pattern), type(self.buffer) )\n        if self.postamble_pattern is not None and len(self.postamble_pattern) > 0:\n            # Try to detect the postamble pattern before the packet_end\n            postamble_len = len(self.postamble_pattern)\n            end_idx = len(self.buffer)\n\n            # Search for the postamble pattern before the packet_end in the buffer\n            for j in range(end_idx - postamble_len, end_idx):\n                if self.buffer[j:j + postamble_len] == self.postamble_pattern:\n                    return j  # Trim the buffer at the point postamble starts\n\n        return len(self.buffer)  # No postamble detected, return full buffer length\n\n\n"
    postamble_pattern: '"0x0f"'
  states: {state: disabled}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: samp_rate // symbol_rate
    taps: numpy.ones(interpolation_factor)
    type: fff
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: interpolation_factor
    taps: numpy.ones(interpolation_factor)
    type: fff
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: 'samp_rate '
    fc: '0'
    fftsize: 1024*2
    name: '"Freq Response of BaseBandSignal"'
    type: float
    update_time: '2'
    wintype: window.WIN_KAISER
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: 1024*2
    name: '"Freq Response of PassBandSignal"'
    type: float
    update_time: '500'
    wintype: window.WIN_KAISER
  states: {}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: 1024*2
    name: '"Freq Response of Demodulated baseBand Signal"'
    type: float
    update_time: '500'
  states: {}
- name: qtgui_freq_sink_x_0_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: (samp_rate/interpolation_factor)/2
    fc: '0'
    fftsize: 1024*2
    name: '"Freq Response of DecimatedFIR o/p"'
    type: float
    update_time: '0.0001'
    ymax: '1'
  states: {}
- name: qtgui_time_sink_x_4_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    name: '"BaseBandSignal"'
    size: 100*256
    srate: samp_rate
    type: float
    update_time: '1'
  states: {}
- name: qtgui_time_sink_x_4_1_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    name: '"PassBandSignal"'
    size: 100*256
    srate: samp_rate
    type: float
    update_time: '1'
  states: {}
- name: qtgui_time_sink_x_4_1_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    comment: |-
      observe aliased frequency components at 10Khz
      cos(2π8kt)⋅cos(2π8kt)=  1/2*x(n) + 1/2*x(n)*cos(2π⋅16kt)

      Aliased frequency=16kHz−25.6kHz=−9.6kHz
    grid: 'True'
    name: '"demodulated Baseband Signal"'
    size: 100*256
    srate: samp_rate
    type: float
    update_time: '1'
  states: {}
- name: qtgui_time_sink_x_4_1_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    entags: 'False'
    grid: 'True'
    name: '"symbols"'
    size: '100'
    srate: 'symbol_rate '
    type: float
    update_time: '1'
  states: {}
- name: qtgui_time_sink_x_4_1_2
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    name: '"Recovered BaseBandSignal"'
    size: '100'
    srate: samp_rate//interpolation_factor
    type: float
    update_time: '1'
  states: {state: disabled}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: BaseBand_Signal
  states: {}
- name: virtual_sink_1_0
  id: virtual_sink
  parameters:
    stream_id: Passband_ASKsignal
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: BaseBand_Signal
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: BaseBand_Signal
  states: {}
- name: virtual_source_1_0_0
  id: virtual_source
  parameters:
    stream_id: Passband_ASKsignal
  states: {}
- name: virtual_source_1_0_0_0
  id: virtual_source
  parameters:
    stream_id: Passband_ASKsignal
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0_0, '1']
- [blocks_file_source_0_0, '0', blocks_stream_mux_0, '1']
- [blocks_float_to_uchar_0, '0', digital_correlate_access_code_tag_xx_1, '0']
- [blocks_multiply_xx_0, '0', virtual_sink_1_0, '0']
- [blocks_multiply_xx_0_0, '0', epy_block_0_0_0_0, '0']
- [blocks_multiply_xx_0_0, '0', fir_filter_xxx_0, '0']
- [blocks_multiply_xx_0_0, '0', qtgui_freq_sink_x_0_0_0, '0']
- [blocks_multiply_xx_0_0, '0', qtgui_time_sink_x_4_1_0_0, '0']
- [blocks_packed_to_unpacked_xx_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [blocks_packed_to_unpacked_xx_0, '0', digital_correlate_access_code_tag_xx_1_0, '0']
- [blocks_stream_mux_0, '0', blocks_stream_mux_0_0, '0']
- [blocks_stream_mux_0, '0', epy_block_0_0_0_1_0, '0']
- [blocks_stream_mux_0_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [blocks_stream_mux_0_0, '0', epy_block_0_0_0_1, '0']
- [blocks_tagged_stream_align_0_0, '0', blocks_tag_debug_0_0_0, '0']
- [blocks_tagged_stream_align_0_0, '0', epy_block_0, '0']
- [blocks_tagged_stream_align_0_0, '0', epy_block_0_0_0_0_0_0, '0']
- [blocks_tagged_stream_align_0_0, '0', epy_block_2, '0']
- [blocks_threshold_ff_0, '0', blocks_float_to_uchar_0, '0']
- [blocks_threshold_ff_0, '0', qtgui_time_sink_x_4_1_2, '0']
- [blocks_throttle2_0, '0', virtual_sink_1, '0']
- [blocks_throttle2_0_0, '0', epy_block_0_0_0, '0']
- [blocks_throttle2_0_0, '0', interp_fir_filter_xxx_0, '0']
- [blocks_throttle2_0_0, '0', qtgui_time_sink_x_4_1_1, '0']
- [blocks_unpacked_to_packed_xx_0_1, '0', blocks_file_sink_0_0, '0']
- [blocks_unpacked_to_packed_xx_0_1, '0', epy_block_0_0_0_0_0_0_1_0, '0']
- [blocks_vector_source_x_0_0, '0', blocks_stream_mux_0, '0']
- [blocks_vector_source_x_0_0_0, '0', blocks_stream_mux_0_0, '1']
- [digital_chunks_to_symbols_xx_0, '0', blocks_throttle2_0_0, '0']
- [digital_correlate_access_code_tag_xx_1, '0', digital_correlate_access_code_tag_xx_1_1, '0']
- [digital_correlate_access_code_tag_xx_1, '0', epy_block_0_0_0_0_0, '0']
- [digital_correlate_access_code_tag_xx_1_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [digital_correlate_access_code_tag_xx_1_1, '0', blocks_tag_debug_0_0_0_0, '0']
- [digital_correlate_access_code_tag_xx_1_1, '0', blocks_tagged_stream_align_0_0, '0']
- [epy_block_0, '0', blocks_unpacked_to_packed_xx_0_1, '0']
- [epy_block_0, '0', epy_block_0_0_0_0_0_0_1, '0']
- [epy_block_2, '0', blocks_tag_debug_0_0_0_1, '0']
- [epy_block_2, '0', blocks_unpacked_to_packed_xx_0_1, '0']
- [fir_filter_xxx_0, '0', blocks_threshold_ff_0, '0']
- [fir_filter_xxx_0, '0', epy_block_0_0_0_0_1, '0']
- [fir_filter_xxx_0, '0', qtgui_freq_sink_x_0_0_0_0, '0']
- [interp_fir_filter_xxx_0, '0', blocks_throttle2_0, '0']
- [virtual_source_1, '0', qtgui_freq_sink_x_0, '0']
- [virtual_source_1, '0', qtgui_time_sink_x_4_1, '0']
- [virtual_source_1_0, '0', blocks_multiply_xx_0, '0']
- [virtual_source_1_0_0, '0', qtgui_freq_sink_x_0_0, '0']
- [virtual_source_1_0_0, '0', qtgui_time_sink_x_4_1_0, '0']
- [virtual_source_1_0_0_0, '0', blocks_multiply_xx_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
