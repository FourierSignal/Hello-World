options:
  parameters:
    generate_options: qt_gui
    id: baseband_to_RF
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: Khz
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: Mhz
  id: variable
  parameters:
    value: 1000*1000
  states: {}
- name: RF_BW
  id: variable
  parameters:
    value: 2*Mhz
  states: {}
- name: fm
  id: variable
  parameters:
    value: 100*Khz
  states: {}
- name: interpolation_factor
  id: variable
  parameters:
    value: 1*Mhz*2
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: symbol_rate*interpolation_factor
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: '1'
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    num_items: 20000*800
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    limit: items
    maximum: '1'
    samples_per_second: symbol_rate
    type: float
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (1, 0, 0,1,0,1,1,1)
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: float
    symbol_table: '[0,0.5]'
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '30.0'
    bandwidth: RF_BW
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: 500*Mhz
    samplerate: samp_rate
    type: fc32
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: RF_BW
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    fpass: '0.5'
    frequency: 500*Mhz
    gain1: '''manual'''
    manual_gain1: '40'
    quadrature: 'True'
    rfdc: 'False'
    samplerate: samp_rate
    type: fc32
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: interpolation_factor
    taps: numpy.ones(interpolation_factor)
    type: fff
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.05'
    bw: 4*fm
    fc: '0'
    fftsize: 512*2
    grid: 'True'
    name: '"Freq Response of BaseBandSignal"'
    type: float
    update_time: '2'
    wintype: window.WIN_BLACKMAN
    ymax: '-1.5'
    ymin: '-2.5'
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.05'
    bw: 2*fm
    fc: 500*Mhz
    fftsize: 1024*2*8*2
    grid: 'True'
    name: '"Freq Response of  RF signal"'
    norm_window: 'True'
    type: float
    update_time: '2'
    wintype: window.WIN_RECTANGULAR
    ymax: '-1.5'
    ymin: '-2.5'
  states: {}
- name: qtgui_time_sink_x_1_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    name: '"RXmodulated Signal"'
    size: 100*1*Khz
    srate: samp_rate
    type: float
    update_time: '500'
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_time_sink_x_4_1_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    name: '"symbols"'
    size: 8*1
    srate: symbol_rate
    type: float
    update_time: '500'
  states: {}
- name: qtgui_time_sink_x_4_1_1_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    name: '"Interpolated symbols"'
    size: 8*interpolation_factor
    srate: symbol_rate*interpolation_factor
    type: float
    update_time: '500'
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: BaseBand_ASKsignal
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: BaseBand_ASKsignal
  states: {}

connections:
- [blocks_complex_to_real_0, '0', blocks_skiphead_0, '0']
- [blocks_float_to_complex_0, '0', iio_pluto_sink_0, '0']
- [blocks_skiphead_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_skiphead_0, '0', qtgui_time_sink_x_1_0_0, '0']
- [blocks_throttle2_0, '0', interp_fir_filter_xxx_0, '0']
- [blocks_throttle2_0, '0', qtgui_time_sink_x_4_1_1, '0']
- [blocks_vector_source_x_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', blocks_throttle2_0, '0']
- [iio_pluto_source_0, '0', blocks_complex_to_real_0, '0']
- [interp_fir_filter_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [interp_fir_filter_xxx_0, '0', qtgui_time_sink_x_4_1_1_0, '0']
- [interp_fir_filter_xxx_0, '0', virtual_sink_1, '0']
- [virtual_source_1, '0', blocks_float_to_complex_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
