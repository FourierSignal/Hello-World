options:
  parameters:
    generate_options: qt_gui
    id: bandlimitedSig
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: Khz
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: Mhz
  id: variable
  parameters:
    value: 1000*1000
  states: {}
- name: RF_BW
  id: variable
  parameters:
    value: 200*Khz
  states: {}
- name: fm
  id: variable
  parameters:
    value: 6*Khz
  states: {}
- name: samp_rate_audio
  id: variable
  parameters:
    value: 44.1*Khz
  states: {}
- name: samp_rate_tx
  id: variable
  parameters:
    value: 529.2*Khz
  states: {}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    device_name: hw:0,0
    samp_rate: '44100'
  states: {}
- name: audio_sink_0_0_0
  id: audio_sink
  parameters:
    device_name: hw:0,0
    samp_rate: '44100'
  states: {state: disabled}
- name: audio_source_0
  id: audio_source
  parameters:
    device_name: hw:0,0
    samp_rate: '44100'
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '30'
    bandwidth: RF_BW
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: 500*Mhz
    samplerate: int(samp_rate_tx)
    type: fc32
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: RF_BW
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: 500*Mhz
    gain1: '''manual'''
    manual_gain1: '20'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: int(samp_rate_tx)
    type: fc32
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 5*Khz
    gain: '5'
    interp: '1'
    samp_rate: samp_rate_audio
    type: interp_fir_filter_fff
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.05'
    bw: samp_rate_audio*20
    fc: '0'
    fftsize: 1024*2*8*2
    grid: 'True'
    name: '"Freq Response of BaseBandSignal"'
    norm_window: 'True'
    type: float
    update_time: '20'
    wintype: window.WIN_RECTANGULAR
    ymax: '-1.5'
    ymin: '-2.5'
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.05'
    bw: 2*samp_rate_tx
    fc: '0'
    fftsize: 1024*2*8*2
    grid: 'True'
    name: '"Freq Response of real Rx baseband signal"'
    norm_window: 'True'
    type: float
    update_time: '2'
    wintype: window.WIN_RECTANGULAR
    ymax: '-1.5'
    ymin: '-2.5'
  states: {}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.05'
    bw: 2000*Mhz
    fc: '0'
    fftsize: 1024*2*8*2
    grid: 'True'
    name: '"Freq Response of Rx complex base band Signal"'
    norm_window: 'True'
    type: complex
    update_time: '2'
    wintype: window.WIN_RECTANGULAR
    ymax: '-1.5'
    ymin: '-2.5'
  states: {}
- name: qtgui_freq_sink_x_0_0_1
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.05'
    bw: 2*samp_rate_audio
    fc: '0'
    fftsize: 1024*2*8*2
    grid: 'True'
    name: '"Freq Response of  downsampled RX baseband"'
    norm_window: 'True'
    type: float
    update_time: '2'
    wintype: window.WIN_RECTANGULAR
    ymax: '-1.5'
    ymin: '-2.5'
  states: {}
- name: qtgui_freq_sink_x_0_1
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.05'
    bw: samp_rate_tx*10
    fc: '0'
    fftsize: 1024*2*8
    grid: 'True'
    name: '"Freq Response of UpsampledBaseBandSignal"'
    norm_window: 'True'
    type: complex
    update_time: '20'
    wintype: window.WIN_RECTANGULAR
    ymax: '-1.5'
    ymin: '-2.5'
  states: {}
- name: qtgui_time_sink_x_1_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    name: '"real Rx base band Signal"'
    size: 20*1000
    srate: samp_rate_tx
    type: float
    update_time: '5'
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_time_sink_x_1_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    name: '"Rx complex base band Signal"'
    size: 20*1000
    srate: samp_rate_tx
    type: complex
    update_time: '5'
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_time_sink_x_1_0_0_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    name: '"down sampled RX real base band Signal"'
    size: 2*1000
    srate: samp_rate_audio
    type: float
    update_time: '5'
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_time_sink_x_4_1_1_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    entags: 'False'
    grid: 'True'
    name: '"BaseBand-Signal"'
    size: '2000'
    srate: samp_rate_audio
    type: float
    update_time: '20'
  states: {}
- name: qtgui_time_sink_x_4_1_1_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    entags: 'False'
    grid: 'True'
    name: '"upsampled complex BaseBand signal"'
    size: 2000*10
    srate: samp_rate_tx
    type: complex
    update_time: '20'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: int(samp_rate_audio)
    interp: int(samp_rate_tx)
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: int(samp_rate_tx)
    interp: int(samp_rate_audio)
    taps: ''
    type: fff
  states: {}

connections:
- [audio_source_0, '0', low_pass_filter_0, '0']
- [blocks_complex_to_real_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_complex_to_real_0, '0', qtgui_time_sink_x_1_0_0, '0']
- [blocks_complex_to_real_0, '0', rational_resampler_xxx_0_0, '0']
- [blocks_float_to_complex_0, '0', rational_resampler_xxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_float_to_complex_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_4_1_1_0, '0']
- [iio_pluto_source_0, '0', blocks_complex_to_real_0, '0']
- [iio_pluto_source_0, '0', qtgui_freq_sink_x_0_0_0, '0']
- [iio_pluto_source_0, '0', qtgui_time_sink_x_1_0_0_0, '0']
- [low_pass_filter_0, '0', audio_sink_0_0_0, '0']
- [low_pass_filter_0, '0', blocks_multiply_const_vxx_0, '0']
- [rational_resampler_xxx_0, '0', iio_pluto_sink_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_freq_sink_x_0_1, '0']
- [rational_resampler_xxx_0, '0', qtgui_time_sink_x_4_1_1_0_0, '0']
- [rational_resampler_xxx_0_0, '0', audio_sink_0_0, '0']
- [rational_resampler_xxx_0_0, '0', qtgui_freq_sink_x_0_0_1, '0']
- [rational_resampler_xxx_0_0, '0', qtgui_time_sink_x_1_0_0_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
