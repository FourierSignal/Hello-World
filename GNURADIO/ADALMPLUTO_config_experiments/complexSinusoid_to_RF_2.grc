options:
  parameters:
    generate_options: qt_gui
    id: baseband_to_RF
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: Khz
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: Mhz
  id: variable
  parameters:
    value: 1000*1000
  states: {}
- name: RF_BW
  id: variable
  parameters:
    value: 2*Mhz
  states: {}
- name: fm
  id: variable
  parameters:
    value: 100*Khz
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2*Mhz
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '0.5'
    freq: fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    num_items: '20000'
    type: float
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '30'
    bandwidth: RF_BW
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: 500*Mhz
    samplerate: samp_rate
    type: fc32
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: RF_BW
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: 500*Mhz
    gain1: '''manual'''
    manual_gain1: '40'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.05'
    bw: fm*2
    fc: '0'
    fftsize: 1024*2*8*2
    grid: 'True'
    name: '"Freq Response of BaseBandSignal"'
    norm_window: 'True'
    type: complex
    update_time: '2'
    wintype: window.WIN_RECTANGULAR
    ymax: '-1.5'
    ymin: '-2.5'
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.05'
    bw: RF_BW*100
    fc: 500*Mhz
    fftsize: 1024*2*8*2
    grid: 'True'
    name: '"Freq Response of  RF signal"'
    norm_window: 'True'
    type: float
    update_time: '2'
    wintype: window.WIN_RECTANGULAR
    ymax: '-1.5'
    ymin: '-2.5'
  states: {}
- name: qtgui_time_sink_x_1_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    name: '"RXmodulated Signal"'
    size: '100'
    srate: samp_rate
    type: float
    update_time: '500'
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_time_sink_x_4_1_1_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    name: '"sine signal"'
    size: 10*(int((1/fm)*samp_rate))
    srate: samp_rate
    type: complex
    update_time: '500'
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_float_to_complex_0, '0']
- [blocks_complex_to_real_0, '0', blocks_skiphead_0, '0']
- [blocks_float_to_complex_0, '0', iio_pluto_sink_0, '0']
- [blocks_float_to_complex_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_float_to_complex_0, '0', qtgui_time_sink_x_4_1_1_0, '0']
- [blocks_skiphead_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_skiphead_0, '0', qtgui_time_sink_x_1_0_0, '0']
- [iio_pluto_source_0, '0', blocks_complex_to_real_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
