options:
  parameters:
    generate_options: qt_gui
    id: ASK_grFlowgraph
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: Mhz
  id: variable
  parameters:
    value: 1000*1000
  states: {}
- name: N
  id: variable
  parameters:
    value: 2**nbits
  states: {}
- name: RF_BW
  id: variable
  parameters:
    value: int(1.5*Mhz)
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.8'
  states: {}
- name: fc
  id: variable
  parameters:
    value: 32000*1
  states: {}
- name: filelength
  id: variable
  parameters:
    value: (1+594+2)
  states: {}
- name: interpolation_factor
  id: variable
  parameters:
    value: int(24)
  states: {}
- name: lpf_taps_downsampling
  id: variable
  parameters:
    value: firdes.low_pass(1.0, samp_rate*64 , samp_rate/(2*interpolation_factor), 200, 1)
  states: {}
- name: lpf_taps_upsampling
  id: variable
  parameters:
    value: firdes.low_pass(1.0, samp_rate*64 , fc+300, 200, 1)
  states: {}
- name: nbits
  id: variable
  parameters:
    value: '2'
  states: {}
- name: ntaps
  id: variable
  parameters:
    comment: |-
      for short bursts of data like 8 symbols 
      ntaps = 16 is ok.  which introduce very small group delay and it does not distort the signal
    value: int(interpolation_factor*11)
  states: {}
- name: qpsk_constellation
  id: variable_constellation
  parameters:
    const_points: '[-1-1j, -1+1j, 1+1j, 1-1j]'
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    sym_map: '[0, 1, 3, 2]'
    type: calcdist
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: numpy.array ( firdes.root_raised_cosine(1,samp_rate,symbol_rate, excess_bw,ntaps ))
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 192*1000
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: 2*50
  states: {}
- name: total_symbols
  id: variable
  parameters:
    value: ((filelength*8)/nbits)/10
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '2'
    min: '0'
    num_samps: '100'
    repeat: 'True'
    type: byte
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1.414'
    freq: fc
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1.414'
    freq: fc
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_2
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: nbits
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {state: disabled}
- name: blocks_throttle2_0_1
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: digital_chunks_to_symbols_xx_0_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: (numpy.exp(1j*2*numpy.pi*numpy.arange(N)/N ))
  states: {state: disabled}
- name: digital_constellation_encoder_bc_0
  id: digital_constellation_encoder_bc
  parameters:
    constellation: qpsk_constellation
  states: {}
- name: epy_block_0_0_0_0_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      class byte_display_block(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(self,
                  name="Byte + ASCII Display Block",
                  in_sig=[np.uint8],
                  out_sig=None)
              self.item_counter = 0  # Initialize item counter

          def work(self, input_items, output_items):
              data = input_items[0]
              for i, byte_val in enumerate(data):
                  try:
                      ascii_char = chr(byte_val) if 32 <= byte_val <= 126 else '.'
                  except:
                      ascii_char = '?'
                  print(f"[{i}] Byte: {byte_val}, ASCII: '{ascii_char}'")
                  self.item_counter += 1
              print(f"Total items printed: {self.item_counter}")
              return len(data)  # Consume all input items
  states: {state: disabled}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt

      class FramingPlusTagInserter(gr.basic_block):
          """
          A sync block that generates a framed packet by adding a preamble and postamble
          to the input bit stream and tags the start and end with 'packet_start' and 'packet_end'.
          """

          def __init__(self, preamble=0xAABBCCDD, postamble=0xEEFF1122):
              gr.basic_block.__init__(
                  self,
                  name="frame_generator",
                  in_sig=[np.uint8],
                  out_sig=[np.uint8]
              )

              self.preamble= list(preamble.to_bytes((preamble.bit_length() + 7) // 8, byteorder='big'))
              self.postamble = list(postamble.to_bytes((postamble.bit_length() + 7) // 8, byteorder='big'))

              self.state = 'preamble'
              self.preamble_index = 0
              self.payload = []
              self.payload_index = 0
              self.postamble_index = 0
              self.packet_start_tagged = False
              self.packet_end_tagged = False
              self.eof_detected = False
              self.transmission_ended = False
              print(self.preamble)

          def find_subsequence(self, data, pattern):
              for i in range(len(data) - len(pattern) + 1):
                  if np.array_equal(data[i:i+len(pattern)], pattern):
                      return i
              return -1  # Not found

          def general_work(self, input_items, output_items):
              inp = input_items[0]
              out = output_items[0]


              noutput_items = len(out)
              in0_length = len(inp)
              space_left_in_out = noutput_items
              produced = 0
              consumed = 0


              #print("\n------>inp=",inp)

              print("in0_length=",in0_length,"noutput_items=",noutput_items)



              if in0_length ==0 and self.state == 'payload' and not self.eof_detected:
                  self.eof_detected = True
                  self.state = 'postamble'
                  print("\n--Entered postamble state")

              if  self.state == 'postamble' and self.transmission_ended == False:

                  while self.postamble_index < len(self.postamble):
                      remaining_postamble = len(self.postamble) - self.postamble_index
                      print("noutput_items=",noutput_items, remaining_postamble)
                      to_copy = min(noutput_items - produced, remaining_postamble)
                      print("to_copy=",to_copy)
                      if to_copy == 0:
                          break
                      print(self.postamble[self.postamble_index:self.postamble_index + to_copy])
                      out[produced:produced + to_copy] = self.postamble[self.postamble_index:self.postamble_index + to_copy]
                      self.postamble_index += to_copy

                      if self.postamble_index == len(self.postamble):
                          self.transmission_ended = True
                      
                      produced += to_copy
                      print("produced=",produced, to_copy)
                      space_left_in_out = noutput_items - produced
                      print("space_left_in_out=",space_left_in_out)
                      if space_left_in_out == 0:
                          self.consume(0, 0)
                          return produced


              elif  self.state == 'postamble' and self.transmission_ended == True:
                  return 0


              while  consumed < len(inp):

                 if self.state == 'preamble':
                      print(self.state)
                      print("len(out)=",len(out))
                      while self.preamble_index < len(self.preamble):

                          remaining_preamble = len(self.preamble) - self.preamble_index
                          print("noutput_items=",noutput_items, remaining_preamble)
                          to_copy = min(noutput_items - produced, remaining_preamble)
                          print("to_copy=",to_copy)
                          if to_copy == 0:
                              break
                          #print(self.preamble[self.preamble_index:self.preamble_index + to_copy])
                          out[produced:produced + to_copy] = self.preamble[self.preamble_index:self.preamble_index + to_copy]
                          self.preamble_index += to_copy
                          produced += to_copy
                          print("produced=",produced, to_copy)
                          space_left_in_out = noutput_items - produced
                          print("space_left_in_out=",space_left_in_out)
                          self.consume(0, 0)
                          return produced


                      if self.preamble_index >= len(self.preamble):
                          self.state = 'payload'
                          self.packet_start_tagged = False  # Reset for new frame
                          produced = 0

                 elif self.state == 'payload':

                      print(self.state)

                      remaining_payload = len(inp) - consumed
                      if remaining_payload == 0:
                          break
                      to_copy = min(space_left_in_out, remaining_payload)
                      print("to_copy=",to_copy,"consumed,produced=",consumed,produced)
                      if not self.packet_start_tagged:
                          # Add tag at the start of payload
                          self.add_item_tag(0, self.nitems_written(0) + produced,
                                            pmt.intern("packet_start"), pmt.PMT_NIL)
                          self.packet_start_tagged = True

                      #print("will output->",inp[consumed:consumed + to_copy])


                      if not self.packet_end_tagged:
                          data_slice = inp[consumed:consumed + to_copy]
                          print("len(data_slice)=",len(data_slice) )
                          match_index = self.find_subsequence(data_slice, self.postamble)
                          if match_index != -1:
                              print("post amble pattern found")
                              tag_position = self.nitems_written(0) + consumed + match_index
                              # one extra bit to accomodate FIR filters tail loss i.e tag at 2nd bit of preamble 
                              self.add_item_tag(0, tag_position,pmt.intern('packet_end'),pmt.PMT_NIL)
                              self.packet_end_tagged = True





                      out[produced:produced + to_copy] = inp[consumed:consumed + to_copy]
                      self.payload.extend(inp[consumed:consumed + to_copy])
                      consumed += to_copy
                      produced += to_copy
                      print("----->consumed,produced= ",consumed,produced)
                      self.consume(0, consumed)
                      return consumed

              print("in while,consumed= ",consumed)
    postamble: '0x0f'
    preamble: '0xaa'
  states: {state: disabled}
- name: epy_block_4
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\nimport numpy as np\nfrom gnuradio import gr\n\nclass file_with_postamble(gr.sync_block):\n    def __init__(self, filename='/tmp/sample.txt', postamble=0xEEFF1122):\n        gr.sync_block.__init__(self,\n            name=\"file_with_postamble\",\n            in_sig=None,\n            out_sig=[np.uint8])\n\n        # Convert integer postamble to byte list\n        self.postamble = list(postamble.to_bytes((postamble.bit_length() + 7) // 8, byteorder='big'))\n\n        print(filename)\n        try:\n            with open(filename, 'rb') as f:\n                raw = np.frombuffer(f.read(), dtype=np.uint8)\n        except IOError as e:\n            print(f\"IOError occurred while opening {filename}: {e}\")\n            raw = np.array([], dtype=np.uint8)\n            \n        #print(\"raw=\",raw)\n        print(\"Length of file (in bytes):\", len(raw))\n        # No bit unpacking, just concatenate bytes\n        self.data = np.concatenate([raw, np.array(self.postamble, dtype=np.uint8)])\n        self.offset = 0\n\n    def work(self, input_items, output_items):\n        out = output_items[0]\n        n = min(len(out), len(self.data) - self.offset)\n        if n > 0:\n            out[:n] = self.data[self.offset:self.offset + n]\n            self.offset += n\n        return n\n\n"
    filename: '''/media/linux1/600GB_EXT4/GNU_radio/GNURadio_src_dev_test_dir/03_flowgraphs/BPSK_tests/alice_excerpt.txt'''
    postamble: '0x0F00'
  states: {state: disabled}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    type: ccf
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: interp_fir_filter_xxx_0_0
  id: interp_fir_filter_xxx
  parameters:
    interp: interpolation_factor
    taps: rrc_taps
    type: ccf
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 32*1000
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: 1*1000
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: 32*1000
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: 1*1000
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: modulatedSig
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: BaseBand_Signal
  states: {state: disabled}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: modulatedSig
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_random_source_x_0, '0', digital_constellation_encoder_bc_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_2, '1']
- [analog_sig_source_x_0_0_0, '0', blocks_multiply_xx_1, '0']
- [blocks_add_xx_0, '0', blocks_multiply_xx_1, '1']
- [blocks_add_xx_0, '0', blocks_multiply_xx_2, '0']
- [blocks_complex_to_real_0, '0', virtual_sink_0, '0']
- [blocks_float_to_complex_0, '0', fir_filter_xxx_0, '0']
- [blocks_multiply_xx_0, '0', blocks_complex_to_real_0, '0']
- [blocks_multiply_xx_1, '0', low_pass_filter_1, '0']
- [blocks_multiply_xx_2, '0', low_pass_filter_0, '0']
- [blocks_packed_to_unpacked_xx_0, '0', digital_chunks_to_symbols_xx_0_0, '0']
- [blocks_throttle2_0_1, '0', interp_fir_filter_xxx_0_0, '0']
- [digital_constellation_encoder_bc_0, '0', blocks_throttle2_0_1, '0']
- [epy_block_1, '0', blocks_packed_to_unpacked_xx_0, '0']
- [epy_block_4, '0', epy_block_0_0_0_0_1, '0']
- [epy_block_4, '0', epy_block_1, '0']
- [fir_filter_xxx_0, '0', qtgui_const_sink_x_0, '0']
- [interp_fir_filter_xxx_0_0, '0', blocks_multiply_xx_0, '0']
- [low_pass_filter_0, '0', blocks_float_to_complex_0, '1']
- [low_pass_filter_1, '0', blocks_float_to_complex_0, '0']
- [virtual_source_0, '0', blocks_add_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
