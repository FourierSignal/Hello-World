options:
  parameters:
    generate_options: qt_gui
    id: ASK_grFlowgraph
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: Mhz
  id: variable
  parameters:
    value: 1000*1000
  states: {}
- name: N
  id: variable
  parameters:
    value: 2**nbits
  states: {}
- name: RF_BW
  id: variable
  parameters:
    value: int(1.5*Mhz)
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.8'
  states: {}
- name: fc
  id: variable
  parameters:
    value: 4000*1
  states: {}
- name: filelength
  id: variable
  parameters:
    value: (1+592+2)
  states: {}
- name: interpolation_factor
  id: variable
  parameters:
    value: '256'
  states: {}
- name: lpf_taps_downsampling
  id: variable
  parameters:
    value: firdes.low_pass(1.0, sample_rate*64 , sample_rate/(2*interpolation_factor), 200, 1)
  states: {}
- name: lpf_taps_upsampling
  id: variable
  parameters:
    value: firdes.low_pass(1.0, sample_rate*64 , fc+300, 200, 1)
  states: {}
- name: nbits
  id: variable
  parameters:
    value: '2'
  states: {}
- name: ntaps
  id: variable
  parameters:
    comment: |-
      for short bursts of data like 8 symbols 
      ntaps = 16 is ok.  which introduce very small group delay and it does not distort the signal
    value: int(interpolation_factor*11)
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: numpy.array ( firdes.root_raised_cosine(1,sample_rate,symbol_rate, excess_bw,ntaps ))
  states: {state: disabled}
- name: rrc_taps
  id: variable_rrc_filter_taps
  parameters:
    alpha: '0.85'
    gain: '1.0'
    ntaps: 11*sps
    samp_rate: sample_rate
    sym_rate: symbol_rate
  states: {}
- name: sample_rate
  id: variable
  parameters:
    value: symbol_rate * interpolation_factor
  states: {}
- name: sps
  id: variable
  parameters:
    value: int(interpolation_factor)
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: 2*50
  states: {}
- name: total_symbols
  id: variable
  parameters:
    value: ((filelength*8)/nbits)/10
  states: {}
- name: zoh_taps
  id: variable
  parameters:
    value: numpy.ones(interpolation_factor)
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: fc
    offset: '0'
    phase: '0'
    samp_rate: sample_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: fc
    offset: '0'
    phase: '0'
    samp_rate: sample_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '10'
    high_cutoff_freq: fc+(150*2)
    low_cutoff_freq: fc-(150*2)
    samp_rate: sample_rate
    type: fir_filter_ccf
    width: '1000'
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: band_reject_filter_0
  id: band_reject_filter
  parameters:
    decim: '1'
    gain: '20'
    high_cutoff_freq: '9100'
    low_cutoff_freq: '6800'
    samp_rate: sample_rate
    type: fir_filter_ccf
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {state: disabled}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /media/linux1/600GB_EXT4/GNU_radio/GNURadio_src_dev_test_dir/03_flowgraphs/BPSK_tests/hello_out.txt
    type: byte
    unbuffered: 'True'
  states: {state: disabled}
- name: blocks_float_to_uchar_0
  id: blocks_float_to_uchar
  parameters:
    bias: '0'
    scale: '1'
    vlen: '1'
  states: {state: disabled}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: int(  (total_symbols*100)*256)
    type: complex
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '100'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '100'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_2
  id: blocks_multiply_const_vxx
  parameters:
    const: '100'
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {state: disabled}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_2
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_null_source_1
  id: blocks_null_source
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: nbits
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_tag_debug_0_0_0
  id: blocks_tag_debug
  parameters:
    name: access_code_debug6
    type: byte
  states: {state: disabled}
- name: blocks_tag_debug_0_0_0_0
  id: blocks_tag_debug
  parameters:
    name: access_code_debug4
    type: byte
  states: {state: disabled}
- name: blocks_tag_debug_0_0_0_0_2
  id: blocks_tag_debug
  parameters:
    name: access_code_debug3
    type: float
  states: {state: disabled}
- name: blocks_tag_debug_0_0_0_0_3
  id: blocks_tag_debug
  parameters:
    name: access_code_debug5
    type: byte
  states: {state: disabled}
- name: blocks_tag_debug_0_0_0_0_3_0
  id: blocks_tag_debug
  parameters:
    name: access_code_debug5
    type: float
  states: {state: disabled}
- name: blocks_tag_debug_0_0_0_1
  id: blocks_tag_debug
  parameters:
    name: access_code_debug3
    type: byte
  states: {state: disabled}
- name: blocks_tagged_stream_align_0_0
  id: blocks_tagged_stream_align
  parameters:
    lengthtagname: packet_start
    type: byte
  states: {state: disabled}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: '120'
    init: '0'
    low: '10'
  states: {state: disabled}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    maximum: '2'
    samples_per_second: sample_rate
    type: complex
  states: {}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    maximum: '2'
    samples_per_second: symbol_rate
    type: complex
  states: {}
- name: blocks_unpacked_to_packed_xx_0_1
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {state: disabled}
- name: digital_chunks_to_symbols_xx_0_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: (numpy.exp(1j*2*numpy.pi*numpy.arange(N)/N ))
  states: {}
- name: digital_correlate_access_code_tag_xx_1
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: '10101010'
    tagname: packet_start
    threshold: '0'
    type: byte
  states: {state: disabled}
- name: digital_correlate_access_code_tag_xx_1_1
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: '00001111'
    tagname: packet_end
    threshold: '0'
    type: byte
  states: {state: disabled}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: N
    w: 2*numpy.pi*sample_rate/(100*sps)
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: '32'
    init_phase: '16'
    loop_bw: 1.5*2*numpy.pi*sample_rate/(100*sps)
    max_dev: '1.0'
    osps: '1'
    sps: sps
    taps: 1*11*sps
    type: ccf
  states: {state: disabled}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt
      import ast

      class ExtractPayLoad(gr.basic_block):
          """
          Forwards input data to output and simultaneously inspects and prints any tags.
          Input and output are streams of bit objects (numpy arrays of 0s and 1s).
          """

          def __init__(self):
              gr.basic_block.__init__(
                  self,
                  name='ExtractPayLoad',
                  in_sig=[np.int8],  # Input is a stream of bits (0 or 1)
                  out_sig=[np.int8]  # Output is a stream of bits (0 or 1)
              )
              self.payload_buffer = []
              self.in_payload = False

          def general_work(self, input_items, output_items):
              in_bits = input_items[0]
              out_bits = output_items[0]
              nread = self.nitems_read(0)
              tags = self.get_tags_in_window(0, 0, len(in_bits))
              tag_offsets = {tag.offset - nread: tag for tag in tags}

              # Directly forward the input to the output
              #out_bits[:] = in_bits
              print("----->in_bits=",in_bits)
              # Inspect and print tags present in the current input buffer
              for offset, tag in tag_offsets.items():
                  key = pmt.to_python(tag.key)
                  value = pmt.to_python(tag.value)
                  print(f"Tag Debug: Offset: {tag.offset}, Relative Offset: {offset}, Key: {key}, Value: {value}")

              consumed = 0
              produced = 0
              i = 0


              # If packet_end is reached and entire buffer is not sent out in previous call, Flush the data is Remaining in Buffer.
              # Output remaining payload if it exists and we're no longer in payload collection
              if not self.in_payload and self.payload_buffer:
                  output_len = min(len(self.payload_buffer), len(out_bits))
                  #print("flushing:len(out_bits)=",len(out_bits), len(self.payload_buffer))
                  if output_len > 0:
                      out_bits[:output_len] = self.payload_buffer[:output_len]
                      self.payload_buffer = self.payload_buffer[output_len:]  # remove outputted
                      self.consume(0, 0)  # No new input consumed in this call
                      return output_len

              while i < len(in_bits):
                  if i in tag_offsets:
                      tag = tag_offsets[i]
                      key = pmt.to_python(tag.key)
                      #print(key,"tag.offset=",tag.offset)

                      if key == 'packet_start':
                          print("Detected packet_start.")
                          print(key,"tag.offset=",tag.offset)
                          self.in_payload = True
                          self.payload_buffer.clear()  

                      elif key == 'packet_end':
                          if self.in_payload:
                              print("Detected packet_end.")
                              print(key,"tag.offset=",tag.offset)
                              self.in_payload = False
                              
                              #print("len(out_bits)=",len(out_bits), len(self.payload_buffer))
                              output_len = min(len(self.payload_buffer), len(out_bits)) # Output as much as fits
                              if output_len > 0:
                                  produced = output_len
                                  consumed = i+1
                                  print("--->produced=",produced,[int(x) for x in self.payload_buffer],"consumed=",consumed)
                                  out_bits[:output_len] = self.payload_buffer[:output_len]
                                  self.payload_buffer = self.payload_buffer[output_len:]
                                  self.consume(0, consumed) 
                                  return produced
                              
                  #print(i,in_bits[i]) 
                  if self.in_payload == True:
                      self.payload_buffer.append(in_bits[i])
                  i += 1
                  consumed = i
              
              print("produced=",produced,[int(x) for x in self.payload_buffer],"consumed=",consumed)
              self.consume(0,consumed)
              # The number of output items produced is the same as the number of input items consumed
              return produced
  states: {state: disabled}
- name: epy_block_0_0_0
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\n\nclass complex_display_block(gr.sync_block):\n    def __init__(self):\n        gr.sync_block.__init__(self,\n            name=\"Complex Display Block\",\n            in_sig=[np.complex64],\n            out_sig=None)\n        self.item_counter = 0  # Initialize item counter\n\n    def work(self, input_items, output_items):\n        for i, val in enumerate(input_items[0]):\n            print(f\"1.Complex[{i}]: {val.real:.4f} + {val.imag:.4f}j\")\n            self.item_counter += 1\n        print(f\"Total items printed: {self.item_counter}\")\n        return len(input_items[0])  # Consume all input items\n\n"
  states: {state: disabled}
- name: epy_block_0_0_0_0
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\n\nclass complex_display_block(gr.sync_block):\n    def __init__(self):\n        gr.sync_block.__init__(self,\n            name=\"Complex Display Block\",\n            in_sig=[np.complex64],\n            out_sig=None)\n        self.item_counter = 0  # Initialize item counter\n\n    def work(self, input_items, output_items):\n        for i, val in enumerate(input_items[0]):\n            print(f\"1.Complex[{i}]: {val.real:.4f} + {val.imag:.4f}j\")\n            self.item_counter += 1\n        print(f\"Total items printed: {self.item_counter}\")\n        return len(input_items[0])  # Consume all input items\n\n"
  states: {state: disabled}
- name: epy_block_0_0_0_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """


      import numpy as np
      from gnuradio import gr

      class float_display_block(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(self,
                  name="Byte Display Block",
                  in_sig=[np.uint8],
                  out_sig=None)
              self.item_counter = 0  # Initialize item counter

          def work(self, input_items, output_items):
              for i, val in enumerate(input_items[0]):  
                  print(f"Byte[{i}]: {val:02x}")
                  self.item_counter += 1 
              print(f"Total items printed: {self.item_counter}")
              return len(input_items[0])  # Consume all input items
  states: {state: disabled}
- name: epy_block_0_0_0_0_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """


      import numpy as np
      from gnuradio import gr

      class float_display_block(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(self,
                  name="Byte Display Block",
                  in_sig=[np.uint8],
                  out_sig=None)
              self.item_counter = 0  # Initialize item counter

          def work(self, input_items, output_items):
              for i, val in enumerate(input_items[0]):  
                  print(f"Byte[{i}]: {val:02x}")
                  self.item_counter += 1 
              print(f"Total items printed: {self.item_counter}")
              return len(input_items[0])  # Consume all input items
  states: {state: disabled}
- name: epy_block_0_0_0_0_0_0_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """


      import numpy as np
      from gnuradio import gr

      class float_display_block(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(self,
                  name="Byte Display Block",
                  in_sig=[np.uint8],
                  out_sig=None)
              self.item_counter = 0  # Initialize item counter

          def work(self, input_items, output_items):
              for i, val in enumerate(input_items[0]):  
                  print(f"Byte[{i}]: {val:02x}")
                  self.item_counter += 1 
              print(f"Total items printed: {self.item_counter}")
              return len(input_items[0])  # Consume all input items
  states: {state: disabled}
- name: epy_block_0_0_0_0_0_0_1_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """


      import numpy as np
      from gnuradio import gr

      class float_display_block(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(self,
                  name="Byte Display Block",
                  in_sig=[np.uint8],
                  out_sig=None)
              self.item_counter = 0  # Initialize item counter

          def work(self, input_items, output_items):
              for i, val in enumerate(input_items[0]):  
                  print(f"Byte[{i}]: {val:02x}")
                  self.item_counter += 1 
              print(f"Total items printed: {self.item_counter}")
              return len(input_items[0])  # Consume all input items
  states: {state: disabled}
- name: epy_block_0_0_0_0_0_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """


      import numpy as np
      from gnuradio import gr

      class float_display_block(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(self,
                  name="Byte Display Block",
                  in_sig=[np.uint8],
                  out_sig=None)
              self.item_counter = 0  # Initialize item counter

          def work(self, input_items, output_items):
              for i, val in enumerate(input_items[0]):  
                  print(f"Byte[{i}]: {val:02x}")
                  self.item_counter += 1 
              print(f"Total items printed: {self.item_counter}")
              return len(input_items[0])  # Consume all input items
  states: {state: disabled}
- name: epy_block_0_0_0_0_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      class byte_display_block(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(self,
                  name="Byte + ASCII Display Block",
                  in_sig=[np.uint8],
                  out_sig=None)
              self.item_counter = 0  # Initialize item counter

          def work(self, input_items, output_items):
              data = input_items[0]
              for i, byte_val in enumerate(data):
                  try:
                      ascii_char = chr(byte_val) if 32 <= byte_val <= 126 else '.'
                  except:
                      ascii_char = '?'
                  print(f"[{i}] Byte: {byte_val}, ASCII: '{ascii_char}'")
                  self.item_counter += 1
              print(f"Total items printed: {self.item_counter}")
              return len(data)  # Consume all input items
  states: {state: disabled}
- name: epy_block_0_0_0_0_2
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\n\nclass complex_display_block(gr.sync_block):\n    def __init__(self):\n        gr.sync_block.__init__(self,\n            name=\"Complex Display Block\",\n            in_sig=[np.complex64],\n            out_sig=None)\n        self.item_counter = 0  # Initialize item counter\n\n    def work(self, input_items, output_items):\n        for i, val in enumerate(input_items[0]):\n            print(f\"1.Complex[{i}]: {val.real:.4f} + {val.imag:.4f}j\")\n            self.item_counter += 1\n        print(f\"Total items printed: {self.item_counter}\")\n        return len(input_items[0])  # Consume all input items\n\n"
  states: {state: disabled}
- name: epy_block_0_0_0_0_3
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\n\nclass complex_display_block(gr.sync_block):\n    def __init__(self):\n        gr.sync_block.__init__(self,\n            name=\"Complex Display Block\",\n            in_sig=[np.complex64],\n            out_sig=None)\n        self.item_counter = 0  # Initialize item counter\n\n    def work(self, input_items, output_items):\n        for i, val in enumerate(input_items[0]):\n            print(f\"1.Complex[{i}]: {val.real:.4f} + {val.imag:.4f}j\")\n            self.item_counter += 1\n        print(f\"Total items printed: {self.item_counter}\")\n        return len(input_items[0])  # Consume all input items\n\n"
  states: {state: disabled}
- name: epy_block_0_0_0_0_4
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\n\nclass complex_display_block(gr.sync_block):\n    def __init__(self):\n        gr.sync_block.__init__(self,\n            name=\"Complex Display Block\",\n            in_sig=[np.complex64],\n            out_sig=None)\n        self.item_counter = 0  # Initialize item counter\n\n    def work(self, input_items, output_items):\n        for i, val in enumerate(input_items[0]):\n            print(f\"1.Complex[{i}]: {val.real:.4f} + {val.imag:.4f}j\")\n            self.item_counter += 1\n        print(f\"Total items printed: {self.item_counter}\")\n        return len(input_items[0])  # Consume all input items\n\n"
  states: {state: disabled}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt

      class FramingPlusTagInserter(gr.basic_block):
          """
          A sync block that generates a framed packet by adding a preamble and postamble
          to the input bit stream and tags the start and end with 'packet_start' and 'packet_end'.
          """

          def __init__(self, preamble=0xAABBCCDD, postamble=0xEEFF1122):
              gr.basic_block.__init__(
                  self,
                  name="frame_generator",
                  in_sig=[np.uint8],
                  out_sig=[np.uint8]
              )

              self.preamble= list(preamble.to_bytes((preamble.bit_length() + 7) // 8, byteorder='big'))
              self.postamble = list(postamble.to_bytes((postamble.bit_length() + 7) // 8, byteorder='big'))

              self.state = 'preamble'
              self.preamble_index = 0
              self.payload = []
              self.payload_index = 0
              self.postamble_index = 0
              self.packet_start_tagged = False
              self.packet_end_tagged = False
              self.eof_detected = False
              self.transmission_ended = False
              print(self.preamble)

          def find_subsequence(self, data, pattern):
              for i in range(len(data) - len(pattern) + 1):
                  if np.array_equal(data[i:i+len(pattern)], pattern):
                      return i
              return -1  # Not found

          def general_work(self, input_items, output_items):
              inp = input_items[0]
              out = output_items[0]


              noutput_items = len(out)
              in0_length = len(inp)
              space_left_in_out = noutput_items
              produced = 0
              consumed = 0


              #print("\n------>inp=",inp)

              print("in0_length=",in0_length,"noutput_items=",noutput_items)



              if in0_length ==0 and self.state == 'payload' and not self.eof_detected:
                  self.eof_detected = True
                  self.state = 'postamble'
                  print("\n--Entered postamble state")

              if  self.state == 'postamble' and self.transmission_ended == False:

                  while self.postamble_index < len(self.postamble):
                      remaining_postamble = len(self.postamble) - self.postamble_index
                      print("noutput_items=",noutput_items, remaining_postamble)
                      to_copy = min(noutput_items - produced, remaining_postamble)
                      print("to_copy=",to_copy)
                      if to_copy == 0:
                          break
                      print(self.postamble[self.postamble_index:self.postamble_index + to_copy])
                      out[produced:produced + to_copy] = self.postamble[self.postamble_index:self.postamble_index + to_copy]
                      self.postamble_index += to_copy

                      if self.postamble_index == len(self.postamble):
                          self.transmission_ended = True
                      
                      produced += to_copy
                      print("produced=",produced, to_copy)
                      space_left_in_out = noutput_items - produced
                      print("space_left_in_out=",space_left_in_out)
                      if space_left_in_out == 0:
                          self.consume(0, 0)
                          return produced


              elif  self.state == 'postamble' and self.transmission_ended == True:
                  return 0


              while  consumed < len(inp):

                 if self.state == 'preamble':
                      print(self.state)
                      print("len(out)=",len(out))
                      while self.preamble_index < len(self.preamble):

                          remaining_preamble = len(self.preamble) - self.preamble_index
                          print("noutput_items=",noutput_items, remaining_preamble)
                          to_copy = min(noutput_items - produced, remaining_preamble)
                          print("to_copy=",to_copy)
                          if to_copy == 0:
                              break
                          #print(self.preamble[self.preamble_index:self.preamble_index + to_copy])
                          out[produced:produced + to_copy] = self.preamble[self.preamble_index:self.preamble_index + to_copy]
                          self.preamble_index += to_copy
                          produced += to_copy
                          print("produced=",produced, to_copy)
                          space_left_in_out = noutput_items - produced
                          print("space_left_in_out=",space_left_in_out)
                          self.consume(0, 0)
                          return produced


                      if self.preamble_index >= len(self.preamble):
                          self.state = 'payload'
                          self.packet_start_tagged = False  # Reset for new frame
                          produced = 0

                 elif self.state == 'payload':

                      print(self.state)

                      remaining_payload = len(inp) - consumed
                      if remaining_payload == 0:
                          break
                      to_copy = min(space_left_in_out, remaining_payload)
                      print("to_copy=",to_copy,"consumed,produced=",consumed,produced)
                      if not self.packet_start_tagged:
                          # Add tag at the start of payload
                          self.add_item_tag(0, self.nitems_written(0) + produced,
                                            pmt.intern("packet_start"), pmt.PMT_NIL)
                          self.packet_start_tagged = True

                      #print("will output->",inp[consumed:consumed + to_copy])


                      if not self.packet_end_tagged:
                          data_slice = inp[consumed:consumed + to_copy]
                          print("len(data_slice)=",len(data_slice) )
                          match_index = self.find_subsequence(data_slice, self.postamble)
                          if match_index != -1:
                              print("post amble pattern found")
                              tag_position = self.nitems_written(0) + consumed + match_index
                              # one extra bit to accomodate FIR filters tail loss i.e tag at 2nd bit of preamble 
                              self.add_item_tag(0, tag_position,pmt.intern('packet_end'),pmt.PMT_NIL)
                              self.packet_end_tagged = True





                      out[produced:produced + to_copy] = inp[consumed:consumed + to_copy]
                      self.payload.extend(inp[consumed:consumed + to_copy])
                      consumed += to_copy
                      produced += to_copy
                      print("----->consumed,produced= ",consumed,produced)
                      self.consume(0, consumed)
                      return consumed

              print("in while,consumed= ",consumed)
    postamble: '0x0f'
    preamble: '0xaa'
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\nimport numpy as np\nfrom gnuradio import gr\nimport pmt\nimport ast\n\nclass extract_payload_block(gr.basic_block):\n    def __init__(self, postamble_pattern=None):\n        gr.basic_block.__init__(\n            self,\n            name=\"extract_payload_block\",\n            in_sig=[np.uint8],   # unpacked bits: 0 or 1\n            out_sig=[np.uint8]   # output same type\n        )\n        self.in_payload = False\n        self.buffer = []\n\n\n        print(f\"Type of postamble_pattern received: {type(postamble_pattern)}\")\n        print(f\"Value of postamble_pattern received: {postamble_pattern}\")\n\n        if isinstance(postamble_pattern, str):\n            try:\n                # Safely evaluate the string as a Python literal\n                self.postamble_pattern = ast.literal_eval(postamble_pattern)\n            except (SyntaxError, ValueError) as e:\n                raise ValueError(f\"Invalid format for postamble_pattern string: {e}\")\n        elif isinstance(postamble_pattern, (int, list, np.ndarray)):\n            # If it's already the correct type, use it directly\n            self.postamble_pattern = postamble_pattern\n        else:\n            raise TypeError(\"postamble_pattern must be a string representing a list, an integer, a list, or a NumPy array\")\n\n        print(f\"Type of self.postamble_pattern after processing: {type(self.postamble_pattern)}\")\n        print(f\"Value of self.postamble_pattern after processing: {self.postamble_pattern}\")\n\n\n\n\n        # Ensure postamble_pattern is a numpy array or list\n        self.postamble_pattern = postamble_pattern\n\n\n\n\n    def general_work(self, input_items, output_items):\n        in0 = input_items[0]\n        out = output_items[0]\n        nread = self.nitems_read(0)\n\n        tags = self.get_tags_in_window(0, 0, len(in0))\n        tag_offsets = {tag.offset - nread: tag for tag in tags}\n\n        i = 0\n        packet_start_idx = None\n        packet_end_idx = None\n\n        # Step 1: Detect start and end tags (packet_start and packet_end)\n        while i < len(in0):\n            if i in tag_offsets and tag_offsets[i].key == pmt.intern(\"packet_start\"):\n                self.in_payload = True\n                self.buffer.clear()\n                packet_start_idx = i\n\n            if i in tag_offsets and tag_offsets[i].key == pmt.intern(\"packet_end\"):\n                packet_end_idx = i\n                if self.in_payload:\n                    self.in_payload = False\n                    break  # Stop once packet_end is found\n\n            if self.in_payload:\n                self.buffer.append(in0[i])\n\n            i += 1\n\n        print(\"packet_end_idx=\",packet_end_idx)\n\n        if not isinstance(self.postamble_pattern, (int, list, np.ndarray)):\n            print(f\"Error: postamble_pattern has incorrect type: {type(self.postamble_pattern)}\")\n            return -1\n\n        # Step 2: If packet_end found, remove postamble\n        if packet_end_idx is not None:\n            # Check and remove postamble before packet_end\n            payload_end_idx = self._remove_postamble(packet_end_idx)\n            self.buffer = self.buffer[:payload_end_idx]\n\n        # Step 3: Output the extracted payload (without postamble)\n        num_to_output = min(len(out), len(self.buffer))\n        out[:num_to_output] = self.buffer[:num_to_output]\n        self.buffer = self.buffer[num_to_output:]\n\n        self.consume(0, i)\n        return num_to_output\n\n    def _remove_postamble(self, packet_end_idx):\n        \"\"\"Detect and remove postamble before the packet_end tag\"\"\"\n\n                # --- Normalize postamble_pattern to a list of ints ---\n\n        if isinstance(postamble_pattern, int):\n\n            postamble_pattern = [postamble_pattern]\n\n        elif isinstance(postamble_pattern, np.ndarray):\n\n            postamble_pattern = postamble_pattern.tolist()\n\n        elif not isinstance(postamble_pattern, list):\n\n            raise TypeError(\"postamble_pattern must be int, list, or numpy array\")\n\n        self.postamble_pattern = np.array(postamble_pattern, dtype=np.uint8) \n\n        print(\"self.postamble_pattern\",self.postamble_pattern,type(self.postamble_pattern))\n\n\n        print( type(self.postamble_pattern), type(self.buffer) )\n        if self.postamble_pattern is not None and len(self.postamble_pattern) > 0:\n            # Try to detect the postamble pattern before the packet_end\n            postamble_len = len(self.postamble_pattern)\n            end_idx = len(self.buffer)\n\n            # Search for the postamble pattern before the packet_end in the buffer\n            for j in range(end_idx - postamble_len, end_idx):\n                if self.buffer[j:j + postamble_len] == self.postamble_pattern:\n                    return j  # Trim the buffer at the point postamble starts\n\n        return len(self.buffer)  # No postamble detected, return full buffer length\n\n\n"
    postamble_pattern: '"0x0f"'
  states: {state: disabled}
- name: epy_block_3
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt

      class tag_delay_block(gr.sync_block):
          def __init__(self, delay_samples = 1):
              gr.sync_block.__init__(self,
                  name="tag_delay_block",
                  in_sig=[np.uint8],
                  out_sig=[np.uint8])
              self.delay_samples = delay_samples

          def work(self, input_items, output_items):
              in0 = input_items[0]
              out0 = output_items[0]
              n = len(in0)

              # Copy samples
              for i in range(n):
                  out0[i] = in0[i]


              tags = self.get_tags_in_range(0, self.nitems_read(0), self.nitems_read(0) + n)

              
              for tag in tags:
                  print("tag.key=",tag.key)
                  key = pmt.symbol_to_string(tag.key)
                  if key in ['packet_start', 'packet_end']: 
                      relative_offset = tag.offset - self.nitems_read(0)
                      new_offset = self.nitems_written(0) + relative_offset
                      output_sample_index = (new_offset + self.delay_samples)
                      print(output_sample_index)
                      self.add_item_tag(0, output_sample_index, tag.key, tag.value)

              #self.consume(0, n)
              return n
    delay_samples: '1'
  states: {state: disabled}
- name: epy_block_4
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\nimport numpy as np\nfrom gnuradio import gr\n\nclass file_with_postamble(gr.sync_block):\n    def __init__(self, filename='/tmp/sample.txt', postamble=0xEEFF1122):\n        gr.sync_block.__init__(self,\n            name=\"file_with_postamble\",\n            in_sig=None,\n            out_sig=[np.uint8])\n\n        # Convert integer postamble to byte list\n        self.postamble = list(postamble.to_bytes((postamble.bit_length() + 7) // 8, byteorder='big'))\n\n        print(filename)\n        try:\n            with open(filename, 'rb') as f:\n                raw = np.frombuffer(f.read(), dtype=np.uint8)\n        except IOError as e:\n            print(f\"IOError occurred while opening {filename}: {e}\")\n            raw = np.array([], dtype=np.uint8)\n            \n        #print(\"raw=\",raw)\n        print(\"Length of file (in bytes):\", len(raw))\n        # No bit unpacking, just concatenate bytes\n        self.data = np.concatenate([raw, np.array(self.postamble, dtype=np.uint8)])\n        self.offset = 0\n\n    def work(self, input_items, output_items):\n        out = output_items[0]\n        n = min(len(out), len(self.data) - self.offset)\n        if n > 0:\n            out[:n] = self.data[self.offset:self.offset + n]\n            self.offset += n\n        return n\n\n"
    filename: '''/media/linux1/600GB_EXT4/GNU_radio/GNURadio_src_dev_test_dir/03_flowgraphs/BPSK_tests/alice_excerpt.txt'''
    postamble: '0x0F00'
  states: {}
- name: filter_fft_rrc_filter_0
  id: filter_fft_rrc_filter
  parameters:
    alpha: '0.85'
    decim: '1'
    gain: '1'
    ntaps: 11*sps
    samp_rate: sample_rate
    sym_rate: '1.0'
    type: ccf
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: sample_rate // symbol_rate
    taps: lpf_taps_downsampling
    type: ccf
  states: {state: disabled}
- name: fir_filter_xxx_1
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: rrc_taps
    type: ccf
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: interpolation_factor
    taps: rrc_taps
    type: ccf
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '1000'
    decim: '1'
    gain: '10'
    samp_rate: sample_rate
    type: fir_filter_ccf
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    size: int( (32/nbits))
    type: complex
    update_time: '2'
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    size: int( total_symbols*interpolation_factor)
    type: complex
    update_time: '2'
  states: {state: disabled}
- name: qtgui_const_sink_x_0_1
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    name: '"After Matched Filtering"'
    size: int( (total_symbols)*256)
    type: complex
    update_time: '2'
  states: {}
- name: qtgui_const_sink_x_0_1_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    name: '"After FIR"'
    size: int( total_symbols)
    type: complex
    update_time: '1'
  states: {}
- name: qtgui_eye_sink_x_0
  id: qtgui_eye_sink_x
  parameters:
    samp_per_symbol: interpolation_factor
    size: int(total_symbols*256)
    srate: sample_rate
    type: complex
    yunit: '"Eye After interpolator"'
  states: {}
- name: qtgui_eye_sink_x_0_0
  id: qtgui_eye_sink_x
  parameters:
    samp_per_symbol: interpolation_factor
    size: int( total_symbols * 256)
    srate: sample_rate
    type: complex
    update_time: '10'
    yunit: '"Eye After matchedFilter"'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: 'sample_rate '
    fc: '0'
    fftsize: 1024*2
    name: '"Freq Response of BaseBandSignal"'
    type: complex
    update_time: '2'
    wintype: window.WIN_KAISER
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: sample_rate
    fc: '0'
    fftsize: 1024*2
    name: '"Freq Response of QPSK"'
    type: complex
    update_time: '500'
    wintype: window.WIN_KAISER
  states: {}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: 1024*2
    name: '"Freq Response of mixer O/P"'
    type: float
    update_time: '500'
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: (sample_rate/interpolation_factor)/2
    fc: '0'
    fftsize: 1024*2
    name: '"Freq Response of DecimatedFIR o/p"'
    type: complex
    update_time: '0.0001'
    ymax: '1'
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0_0_1
  id: qtgui_freq_sink_x
  parameters:
    bw: sample_rate
    fc: '0'
    fftsize: 1024*2
    name: '"Freq Response of mixer o/p"'
    type: complex
    update_time: '500'
  states: {}
- name: qtgui_freq_sink_x_0_0_0_1_0
  id: qtgui_freq_sink_x
  parameters:
    bw: sample_rate
    fc: '0'
    fftsize: 1024*2
    name: '"Freq Response of BPF pluto o/p Signal"'
    type: complex
    update_time: '500'
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0_0_1_1
  id: qtgui_freq_sink_x
  parameters:
    bw: sample_rate
    fc: '0'
    fftsize: 1024*2
    name: '"Freq Response of MatchedFilt o/p"'
    type: complex
    update_time: '500'
  states: {}
- name: qtgui_freq_sink_x_0_0_0_2
  id: qtgui_freq_sink_x
  parameters:
    bw: sample_rate
    fc: '0'
    fftsize: 1024*2
    name: '"Freq Response of Rxed pluto sig"'
    type: complex
    update_time: '500'
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0_1
  id: qtgui_freq_sink_x
  parameters:
    bw: sample_rate*64
    fc: '0'
    fftsize: 1024*2*2
    name: '"Freq Response of ASK after upsamling"'
    type: complex
    update_time: '500'
    wintype: window.WIN_KAISER
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_1
  id: qtgui_freq_sink_x
  parameters:
    bw: 'sample_rate '
    fc: '0'
    fftsize: 1024*2
    name: '"Freq Response of symbols"'
    type: complex
    update_time: '2'
    wintype: window.WIN_KAISER
  states: {}
- name: qtgui_time_sink_x_4_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    name: '"BaseBandSignal"'
    size: int(total_symbols*256)
    srate: sample_rate
    type: complex
    update_time: '1'
  states: {}
- name: qtgui_time_sink_x_4_1_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    entags: 'False'
    grid: 'True'
    name: '"mixer o/p "'
    size: int( total_symbols *256)
    srate: sample_rate
    type: complex
    update_time: '10'
  states: {}
- name: qtgui_time_sink_x_4_1_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    entags: 'False'
    grid: 'True'
    name: '"decimating FIR o/p Signal"'
    size: int(total_symbols)
    srate: sample_rate
    type: complex
    update_time: '10'
  states: {}
- name: qtgui_time_sink_x_4_1_0_0_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    entags: 'False'
    grid: 'True'
    name: '"mixer o/p after matched  "'
    size: int( total_symbols*256)
    srate: sample_rate
    type: complex
    update_time: '10'
  states: {}
- name: qtgui_time_sink_x_4_1_0_0_1_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    entags: 'False'
    grid: 'True'
    name: '" Rxed pluto sig"'
    size: 1*256*64
    srate: sample_rate*64
    type: complex
    update_time: '10'
  states: {state: disabled}
- name: qtgui_time_sink_x_4_1_0_0_1_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    entags: 'False'
    grid: 'True'
    name: '"pluto O/p Signal after resampling and BPF"'
    size: int(total_symbols*256)
    srate: sample_rate
    type: complex
    update_time: '50'
  states: {state: disabled}
- name: qtgui_time_sink_x_4_1_0_0_1_2
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    entags: 'False'
    grid: 'True'
    name: '"costas o/p "'
    size: int( total_symbols*256)
    srate: sample_rate
    type: complex
    update_time: '1'
  states: {}
- name: qtgui_time_sink_x_4_1_0_0_1_2_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    entags: 'False'
    grid: 'True'
    name: '" symbol sync o/p "'
    size: int( total_symbols*256)
    srate: sample_rate
    type: complex
    update_time: '1'
  states: {state: disabled}
- name: qtgui_time_sink_x_4_1_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    entags: 'False'
    grid: 'True'
    name: '"symbols"'
    size: int(total_symbols)
    srate: 'symbol_rate '
    type: complex
    update_time: '1'
  states: {}
- name: qtgui_time_sink_x_4_1_2
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    name: '"Mixer output"'
    size: int((32/nbits)*256)
    srate: sample_rate//interpolation_factor
    type: float
    update_time: '1'
  states: {state: disabled}
- name: qtgui_time_sink_x_4_1_3
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    name: '"QPSK before upsamling"'
    size: int((total_symbols/10) *256)
    srate: sample_rate
    type: complex
    update_time: '10'
  states: {}
- name: qtgui_time_sink_x_4_1_3_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    name: '"QPSK  after upsamling"'
    size: 12*256*64
    srate: sample_rate*64
    type: complex
    update_time: '20'
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: passBandBpskSignal
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: BaseBand_Signal
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: Mixer output
  states: {}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: filtered pluto output
  states: {state: disabled}
- name: virtual_sink_4
  id: virtual_sink
  parameters:
    stream_id: matchedFilter_op
  states: {}
- name: virtual_sink_5
  id: virtual_sink
  parameters:
    stream_id: synchronizedSignal
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: synchronizedSignal
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: Mixer output
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: BaseBand_Signal
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: BaseBand_Signal
  states: {}
- name: virtual_source_1_0_0
  id: virtual_source
  parameters:
    stream_id: passBandBpskSignal
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0_0, '1']
- [band_pass_filter_0, '0', qtgui_freq_sink_x_0_0_0_1_0, '0']
- [band_pass_filter_0, '0', qtgui_time_sink_x_4_1_0_0_1_1, '0']
- [band_pass_filter_0, '0', virtual_sink_3, '0']
- [band_reject_filter_0, '0', low_pass_filter_0, '0']
- [blocks_complex_to_real_0, '0', qtgui_time_sink_x_4_1_2, '0']
- [blocks_float_to_uchar_0, '0', blocks_tag_debug_0_0_0_0, '0']
- [blocks_float_to_uchar_0, '0', digital_correlate_access_code_tag_xx_1, '0']
- [blocks_float_to_uchar_0, '0', epy_block_0_0_0_0_0_1, '0']
- [blocks_float_to_uchar_0, '0', epy_block_3, '0']
- [blocks_head_0, '0', band_reject_filter_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_throttle2_0, '0']
- [blocks_multiply_const_vxx_1, '0', qtgui_const_sink_x_0_1_0, '0']
- [blocks_multiply_const_vxx_1, '0', qtgui_time_sink_x_4_1_0_0_0, '0']
- [blocks_multiply_const_vxx_2, '0', filter_fft_rrc_filter_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_time_sink_x_4_1_3, '0']
- [blocks_multiply_xx_0, '0', virtual_sink_0, '0']
- [blocks_multiply_xx_0_0, '0', band_reject_filter_0, '0']
- [blocks_multiply_xx_0_0, '0', blocks_head_0, '0']
- [blocks_null_source_1, '0', band_pass_filter_0, '0']
- [blocks_packed_to_unpacked_xx_0, '0', digital_chunks_to_symbols_xx_0_0, '0']
- [blocks_tagged_stream_align_0_0, '0', blocks_null_sink_0, '0']
- [blocks_tagged_stream_align_0_0, '0', blocks_tag_debug_0_0_0, '0']
- [blocks_tagged_stream_align_0_0, '0', epy_block_0, '0']
- [blocks_tagged_stream_align_0_0, '0', epy_block_0_0_0_0_0_0, '0']
- [blocks_tagged_stream_align_0_0, '0', epy_block_2, '0']
- [blocks_throttle2_0, '0', virtual_sink_1, '0']
- [blocks_throttle2_0_0, '0', blocks_tag_debug_0_0_0_0_2, '0']
- [blocks_throttle2_0_0, '0', epy_block_0_0_0, '0']
- [blocks_throttle2_0_0, '0', interp_fir_filter_xxx_0, '0']
- [blocks_throttle2_0_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_throttle2_0_0, '0', qtgui_freq_sink_x_0_1, '0']
- [blocks_throttle2_0_0, '0', qtgui_time_sink_x_4_1_1, '0']
- [blocks_unpacked_to_packed_xx_0_1, '0', blocks_file_sink_0_0, '0']
- [blocks_unpacked_to_packed_xx_0_1, '0', epy_block_0_0_0_0_0_0_1_0, '0']
- [digital_chunks_to_symbols_xx_0_0, '0', blocks_throttle2_0_0, '0']
- [digital_correlate_access_code_tag_xx_1, '0', digital_correlate_access_code_tag_xx_1_1, '0']
- [digital_correlate_access_code_tag_xx_1, '0', epy_block_0_0_0_0_0, '0']
- [digital_correlate_access_code_tag_xx_1_1, '0', blocks_tag_debug_0_0_0_0, '0']
- [digital_correlate_access_code_tag_xx_1_1, '0', blocks_tagged_stream_align_0_0, '0']
- [digital_costas_loop_cc_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [digital_costas_loop_cc_0, '0', digital_symbol_sync_xx_0, '0']
- [digital_costas_loop_cc_0, '0', fir_filter_xxx_1, '0']
- [digital_costas_loop_cc_0, '0', qtgui_time_sink_x_4_1_0_0_1_2, '0']
- [digital_pfb_clock_sync_xxx_0, '0', virtual_sink_5, '0']
- [digital_symbol_sync_xx_0, '0', epy_block_0_0_0_0_3, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_time_sink_x_4_1_0_0_1_2_0, '0']
- [digital_symbol_sync_xx_0, '0', virtual_sink_5, '0']
- [epy_block_0, '0', blocks_unpacked_to_packed_xx_0_1, '0']
- [epy_block_0, '0', epy_block_0_0_0_0_0_0_1, '0']
- [epy_block_1, '0', blocks_packed_to_unpacked_xx_0, '0']
- [epy_block_2, '0', blocks_tag_debug_0_0_0_1, '0']
- [epy_block_2, '0', blocks_unpacked_to_packed_xx_0_1, '0']
- [epy_block_3, '0', blocks_tag_debug_0_0_0_0_3, '0']
- [epy_block_3, '0', blocks_tagged_stream_align_0_0, '0']
- [epy_block_3, '0', epy_block_0, '0']
- [epy_block_4, '0', epy_block_0_0_0_0_1, '0']
- [epy_block_4, '0', epy_block_1, '0']
- [filter_fft_rrc_filter_0, '0', digital_costas_loop_cc_0, '0']
- [fir_filter_xxx_0, '0', blocks_multiply_const_vxx_1, '0']
- [fir_filter_xxx_0, '0', blocks_null_sink_1, '0']
- [fir_filter_xxx_0, '0', epy_block_0_0_0_0, '0']
- [fir_filter_xxx_0, '0', qtgui_freq_sink_x_0_0_0_0, '0']
- [fir_filter_xxx_1, '0', qtgui_const_sink_x_0_1, '0']
- [fir_filter_xxx_1, '0', qtgui_eye_sink_x_0_0, '0']
- [fir_filter_xxx_1, '0', qtgui_freq_sink_x_0_0_0_1_1, '0']
- [fir_filter_xxx_1, '0', qtgui_time_sink_x_4_1_0_0_1, '0']
- [fir_filter_xxx_1, '0', virtual_sink_4, '0']
- [interp_fir_filter_xxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [interp_fir_filter_xxx_0, '0', qtgui_const_sink_x_0_0, '0']
- [low_pass_filter_0, '0', blocks_complex_to_real_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0_0_0_1, '0']
- [low_pass_filter_0, '0', qtgui_time_sink_x_4_1_0_0, '0']
- [low_pass_filter_0, '0', virtual_sink_2, '0']
- [virtual_source_0, '0', blocks_multiply_const_vxx_1, '0']
- [virtual_source_0, '0', blocks_null_sink_1, '0']
- [virtual_source_0, '0', epy_block_0_0_0_0_4, '0']
- [virtual_source_0, '0', fir_filter_xxx_0, '0']
- [virtual_source_0_0, '0', blocks_multiply_const_vxx_2, '0']
- [virtual_source_0_0, '0', epy_block_0_0_0_0_2, '0']
- [virtual_source_1, '0', qtgui_eye_sink_x_0, '0']
- [virtual_source_1, '0', qtgui_freq_sink_x_0, '0']
- [virtual_source_1, '0', qtgui_time_sink_x_4_1, '0']
- [virtual_source_1_0, '0', blocks_multiply_xx_0, '1']
- [virtual_source_1_0_0, '0', blocks_multiply_xx_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
